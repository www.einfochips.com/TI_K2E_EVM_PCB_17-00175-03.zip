# Allegro board TI_K2E_EVM_PCB_17-00175-03.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N26588382: length 5.2
  TOP w0.152: v1(51.54,90.95) 51.54,92.1 TP96.1
  BOTTOM w0.152: v1(51.54,90.95) 51.54,90.7 51.98,90.26 52.39,90.26 52.79,89.87 52.79,88.95 52.39,88.56 R638.2
N26588389: length 4.8
  TOP w0.152: TP97.1 52.73,88.52 v1(53.01,88.24)
  BOTTOM w0.152: v1(53.01,88.24) 53.01,87.78 51.72,86.49 R640.2
N26588687: length 2.1
  BOTTOM w0.152: U80.2 48.18,92.25 48.26,92.33 R654.1
N27153251: length 3.6
  BOTTOM w0.152: R660.2 32.83,39.94 32.59,39.7 32.59,38.96 31.77,38.14 U75.45
N27316416: length 3
  BOTTOM w0.152: U36.6 116.95,144.81 R299.1 R662.2
N27515257: length 1.4
  TOP w0.152: R676.1 100.23,132.97 U3.3
N27516300: length 1.7
  TOP w0.152: U3.1 100.47,133.97 100.36,134.09 100.36,134.79 R669.2
N27516648: length 1.6
  TOP w0.152: R668.2 92.53,133.59 92.89,133.22 U81.2
N27517289: length 1.3
  TOP w0.152: R666.1 97.02,132.57 U81.4
N27517976: length 10.8
  TOP w0.152: v1(98.25,131.67) 97.94,131.99 R666.2 ; R671.2 105.16,133.25 v1(105.11,133.3) 104.93,133.47 U3.7
  L5_SIG2 w0.107: v1(105.11,133.3) 102.21,133.3 100.13,131.22 98.81,131.22 98.35,131.67 v1(98.25,131.67)
N56425294: length 9.3
  TOP w0.102: AMC1.53 4.84,44.25 5.09,44.5 12.14,44.5 12.25,44.39 C165.1
N56425297: length 9.3
  TOP w0.102: C162.1 12.25,44.86 12.14,44.75 5.09,44.75 4.84,45 AMC1.54
N56425300: length 9.3
  TOP w0.102: C187.1 12.25,39.89 12.14,40 5.09,40 4.84,39.75 AMC1.47
N56425303: length 9.3
  TOP w0.102: AMC1.48 4.84,40.5 5.09,40.25 12.12,40.25 12.25,40.39 C176.1
N66223400: length 8.9
  TOP w0.102: U23.G3 v6(70.38,72.56)
  BOTTOM w0.102: C457.2 71.34,78.38 71.77,78.38 71.82,78.33 71.82,77.88 71.62,77.67 70.78,77.67 70.38,77.26 70.38,76.95 70.18,76.76 70.18,76.53 70.38,76.33 70.38,76.11 70.18,75.91 70.18,75.68 70.38,75.49 70.38,75.26 70.18,75.06 70.18,74.83 70.38,74.64 70.38,74.41 70.18,74.21 70.18,73.98 70.38,73.79 70.38,73.56 70.18,73.36 70.18,73.14 70.38,72.94 v6(70.38,72.56)
N66223405: length 8.9
  TOP w0.102: U23.G4 v6(70.38,71.76)
  BOTTOM w0.102: C456.2 72.21,78.29 72.07,78.16 72.07,77.77 71.72,77.42 70.89,77.42 70.63,77.16 70.63,72.83 70.74,72.71 70.74,72.4 70.38,72.03 v6(70.38,71.76)
N68025719: length 2.6
  TOP w0.152: R39.2 135.98,127.07 135.69,127.36 U1.31
N68025736: length 2.7
  TOP w0.152: U1.30 135.19,127.34 134.92,127.07 R40.2
N68027970: length 2.6
  TOP w0.152: v1(89.84,143.34) SW1.8
  BOTTOM w0.152: R296.1 v1(89.84,143.34)
N68027994: length 2.6
  TOP w0.152: v1(92.38,143.34) SW1.7
  BOTTOM w0.152: R295.1 v1(92.38,143.34)
N68028184: length 2.6
  TOP w0.152: v1(94.92,143.34) SW1.6
  BOTTOM w0.152: R294.1 v1(94.92,143.34)
N68028192: length 2.6
  TOP w0.152: v1(97.46,143.34) SW1.5
  BOTTOM w0.152: R293.1 v1(97.46,143.34)
N68029449: length 5.8
  TOP w0.152: RST_PWR1.1 R181.1
N68029469: length 5.8
  TOP w0.152: RST_ATTN1.1 R211.1
N68035165: length 34.1
  TOP w0.152: U1.38 139.19,128.3 v1(139.16,128.26) ; U1.7 v1(133.07,140.16) 137.92,140.16 v1(139.88,142.11) 139.19,142.8 U1.88
  L8_SIG3 w0.107: v1(139.88,142.11) 138.68,140.92 138.68,128.74 v1(139.16,128.26)
  BOTTOM w0.152: C318.1 v1(133.07,140.16) ; C338.1 139.19,128.3 v1(139.16,128.26) ; C298.1 139.57,145.48 139.75,145.31 139.75,144.36 139.47,144.08 139.47,143.15 139.88,142.74 v1(139.88,142.11)
N68049827: length 8.4
  TOP w0.152: TP25.1 78.92,102.67 78.92,100.7 79.51,100.11 82.2,100.11 83.05,99.26 83.05,99.26 U17.45
N68049869: length 4.6
  TOP w0.152: R154.2 78.53,97.66 78.84,97.35 78.84,95.76 79.48,95.12 U17.6
N68057675: length 3
  TOP w0.152: U18.1 62.07,97.62 61.6,98.09 R151.2
N68057679: length 9
  TOP w0.152: TP26.1 60.81,103.48 60.81,100.74 61.82,99.72 64.61,99.72 65.17,99.16 U18.45
N68057721: length 3.8
  TOP w0.152: R157.2 60.14,95.78 60.8,95.12 U18.6
N68057761: length 3.2
  TOP w0.254: C42.2 67.67,100.67 U18.40
N68057795: length 6
  TOP w0.152: R138.2 59.94,100.51 61.37,99.09 63.93,99.09 64.17,98.85 U18.47
N68067792: length 3.2
  TOP w0.152: U17.1 80.1,97.62 78.66,99.06 R150.2
N68067794: length 6
  TOP w0.152: R135.2 77.95,100.43 79.1,99.29 81.76,99.29 82.05,99 U17.47
N68073129: length 3.3
  TOP w0.152: R28.2 147.56,130.04 147.01,130.58 U1.51

## Copper pours and planes (outline as drawn)
AGND on TOP: 58.5,1.19 58.5,3.57 58.3,3.76 58.3,5.22 58.67,5.59 59.18,5.59 59.54,5.94 59.54,6.1 59.66,6.22 59.92,6.22 60.07,6.07 60.07,5.71 60.71,5.08 60.71,4.45 60.53,4.27 60.53,3.58 62.15,1.96 64.16,1.96 64.49,2.29 64.49,2.64 64.64,2.79 65.28,2.79 65.41,2.92 65.41,5.71 65.66,5.46 65.66,4.45 66.17,3.94 66.17,2.24 66.52,1.88 69.39,1.88 70.18,2.67 70.18,7.24 70.31,7.37 72.01,7.37 72.14,7.24 72.14,1.14 72.01,1.02 58.67,1.02
AGND on TOP: 56.92,7.98 57.12,7.77 57.99,7.77 58.27,8.05 59.11,8.05 59.31,8.26 59.31,8.81 59.23,8.89 55.12,8.89 54.97,8.74 54.97,8.15 55.14,7.98
AGND on L2_GND1: 61.16,9.09 62.15,8.1 62.15,6.99 63.32,5.82 66.57,5.82 66.75,5.99 66.75,7.04 66.85,7.14 69.14,7.14 69.49,7.49 72.06,7.49 72.14,7.42 72.14,1.6 71.58,1.04 58.24,1.04 57.56,1.73 57.56,4.9 54.81,7.65 54.81,8.81 55.09,9.09
AGND1 on L2_GND1: 106.5,19.23 106.05,19.68 95.89,19.68 95.38,19.18 95.38,8 96.9,6.48 96.9,3.43 97.92,2.41 103.76,2.41 104.65,3.3 105.16,3.3 106.5,4.65
AVCC3V3_1 on BOTTOM: 146.18,14.35 143.51,14.35 143.26,14.61 141.76,14.61 141.66,14.5 141.66,13.21 141.78,13.08 146.18,13.08 146.3,13.21 146.3,14.22
AVCC3V3_1 on L8_SIG3: 134.04,15.72 134.04,11.96 131.8,9.73 131.8,8.86 132.11,8.56 143.1,8.56 143.46,8.92 143.46,13.18 140.31,16.33 134.65,16.33
AVCC3V3_2 on BOTTOM: 149.17,38.05 149.1,38.13 144.75,38.13 144.65,38.02 144.65,37.06 144.78,36.93 149.07,36.93 149.17,37.03
AVCC3V3_2 on L5_SIG2: 133.99,34.11 133.99,32.69 134.42,32.26 138.96,32.26 141.55,34.85 144.96,34.85 146.41,36.3 146.41,40.84 145.97,41.27 136.09,41.27 135.71,40.89 135.71,35.84
AVDD1V8_1 on BOTTOM: 147.07,11.18 146.05,11.18 145.8,11.43 141.71,11.43 141.6,11.53 141.6,12.55 141.76,12.7 146.94,12.7 147.32,12.32 147.32,11.43
AVDD1V8_1 on L3_SIG1: 127.43,20.78 127.43,13.72 126.39,12.67 126.39,9.83 127.53,8.69 143.31,8.69 143.59,8.97 143.59,16.59 141.45,18.72 139.32,18.72 135.08,22.96 129.62,22.96
AVDD1V8_2 on BOTTOM: 141.38,33.45 147.37,33.45 147.45,33.53 147.45,34.14 146.96,34.62 141.43,34.62 141.27,34.47 141.27,33.55
AVDD1V8_2 on L3_SIG1: 129.16,44.88 129.16,35.15 128.52,34.52 128.52,33.35 129.11,32.77 132.23,32.77 133.05,31.95 143.94,31.95 146.15,34.16 146.15,46.05 145.26,46.94 134.44,46.94 133.81,46.3 130.58,46.3
AVDDA1 on BOTTOM: 32.82,70.87 31.93,70.87 31.5,71.3 31.5,72.72 31.62,72.85 32.82,72.85 33.15,72.52 33.15,71.2
AVDDA1 on L3_SIG1: 54.84,68.28 54.84,69.52 54.64,69.72 54.25,69.72 54.05,69.93 54.05,70.33 53.77,70.61 53.39,70.61 53.24,70.76 53.24,71.17 52.98,71.42 52.63,71.42 52.4,71.65 52.4,72.03 52.2,72.24 48.49,72.24 47.02,73.71 32.66,73.71 32.11,73.15 32.11,70.36 34.29,68.17 47.98,68.17 48.08,68.07 54.64,68.07
AVDDA3 on L5_SIG2: 56.34,69.19 56.34,69.72 56.21,69.85 54.2,69.85 54,70.05 54,70.46 53.8,70.66 52.63,70.66 52.48,70.82 52.48,71.3 52.32,71.45 51.82,71.45 51.66,71.6 51.66,73.25 49.12,75.79 44.78,75.79 44.77,75.81 42.43,75.81 40.34,77.9 40.34,80.24 40.18,80.39 37.95,80.39 37.69,80.14 37.69,77.39 42.37,72.72 46.28,72.72 50.11,68.88 55.37,68.88 55.63,69.14 56.29,69.14
DVDD1V0 on TOP: 44.45,33.02 43.03,33.02 42.14,33.91 41.4,33.91 40.13,32.64 40.13,29.57 39.93,29.36 37.31,29.36 37.21,29.46 37.21,32.84 37.41,33.05 38.63,33.05 38.81,33.22 38.81,34.34 38.56,34.59 37.31,34.59 37.21,34.7 37.21,37.19 36.98,37.41 35.53,37.41 34.72,36.6 32.38,36.6 32.21,36.78 32.21,38.51 32.84,39.14 40.18,39.14 44.58,34.75 44.58,33.15
DVDD1V0_1 on BOTTOM: 127.89,9.02 127.89,4.19 128.14,3.94 129.92,3.94 130.05,4.06 130.05,5.84 129.92,5.97 128.91,5.97 128.65,6.22 128.65,8.89 128.52,9.02
DVDD1V0_1 on L8_SIG3: 127.64,21.95 127.64,4.06 128.32,3.38 130.94,3.38 131.47,3.91 131.47,8.56 130.86,9.17 130.86,10.34 131.8,11.28 131.8,16.74 133.5,18.44 133.5,20.8 133.35,20.95 133.35,22.83 133.05,23.14 128.83,23.14
DVDD1V0_2 on BOTTOM: 129.87,32.38 129.87,28.12 130.23,27.76 131.85,27.76 132.21,28.12 132.21,29.24 131.7,29.74 130.84,29.74 130.53,30.05 130.53,32.33 130.38,32.49 129.97,32.49
DVDD1V0_2 on L8_SIG3: 130.84,45.47 130.84,27.38 131.09,27.13 134.19,27.13 134.59,27.53 134.59,31.24 133.05,32.79 133.05,33.93 134.32,35.2 134.32,41.17 136.17,43.03 136.17,46.76 135.46,47.47 132.84,47.47
GND on TOP (solid shape): 117.2,29.74 117.2,26.42 116.69,25.91 111.4,25.91 111.07,26.24 111.07,30.02 111.28,30.23 116.71,30.23
GND on TOP (solid shape): 117.3,95.43 117.3,92.1 116.79,91.59 111.51,91.59 111.18,91.92 111.18,95.71 111.38,95.91 116.81,95.91
GND on TOP (solid shape): 167.28,143.13 167.28,142.44 167.18,142.34 162.59,142.34 162.51,142.42 162.51,143.18 162.59,143.26 167.16,143.26
GND on TOP (solid shape): 143,89.59 143,88.39 142.11,87.5 142.11,85.98 141.76,85.62 141.76,83.85 141.63,83.72 141.22,83.72 140.89,84.05 140.89,89.69 141.12,89.92 142.67,89.92
GND on TOP (solid shape): 167.51,98.91 167.51,97.54 167.89,97.16 167.89,95 167.77,94.87 166.88,94.87 166.75,95 166.75,97.54 166.31,97.98 166.31,98.89 166.55,99.14 167.28,99.14
GND on TOP (solid shape): 144.58,80.06 144.58,78.79 145.16,78.21 145.16,76.83 144.98,76.66 144.48,76.66 144.45,76.68 144.45,78.35 144.22,78.57 144.22,80.09 144.27,80.14 144.5,80.14
GND on TOP (solid shape): 154.58,81.13 154.58,79.12 154.36,78.89 147.96,78.89 147.8,79.04 147.8,79.73 147.96,79.88 149.96,79.88 150.47,80.39 152.6,80.39 152.76,80.54 152.76,81.15 152.88,81.28 154.43,81.28
GND on TOP (solid shape): 146.71,89.33 146.71,86.33 146.99,86.06 148.16,86.06 148.41,85.8 148.41,85.04 148.18,84.81 146.28,84.81 145.72,85.37 145.72,87.35 145.9,87.53 145.9,89.35 146.04,89.48 146.56,89.48
GND on TOP (solid shape): 124.36,18.01 124.36,8.01 123.95,7.61 113.46,7.61 113.28,7.78 113.28,10.29 112.65,10.92 107.92,10.92 107.49,11.35 107.49,11.81 107.75,12.06 113.49,12.06 113.89,12.47 113.89,14.86 113.16,15.6 113.16,18.03 113.41,18.29 124.08,18.29
GND on TOP (solid shape): 145.03,81.99 145.03,80.37 144.98,80.31 143.13,80.31 143.05,80.24 142.13,80.24 141.61,79.72 137.16,79.72 136.99,79.88 134.82,79.88 134.57,79.63 133.99,79.63 133.81,79.8 133.81,81.62 133.99,81.79 137.06,81.79 137.19,81.66 137.19,80.88 137.55,80.52 142.21,80.52 142.27,80.57 143.21,80.57 143.26,80.62 143.26,81.97 143.31,82.02 145.01,82.02
GND on TOP (solid shape): 88.7,19.02 88.7,16.23 88.46,15.99 87.54,15.99 87.53,16 82.14,16 81.61,15.47 81.61,10.06 82.65,9.02 87.5,9.02 87.76,9.27 87.76,11.56 88.14,11.94 96.27,11.94 96.77,12.45 97.66,12.45 97.79,12.32 97.79,11.68 97.66,11.56 95.63,11.56 95,10.92 89.41,10.92 89.28,10.79 89.28,3.68 89.15,3.56 82.42,3.56 82.04,3.94 79.76,3.94 78.74,4.95 78.74,19.02 79.24,19.53 88.19,19.53
GND on BOTTOM (solid shape): 42.93,146.13 42.93,144.22 42.7,143.99 41.07,143.99 40.92,144.15 40.92,146.1 41.15,146.33 42.72,146.33
GND on BOTTOM (solid shape): 172.01,142.14 172.01,141.1 171.91,141 170.74,141 170.61,141.12 170.61,142.14 170.81,142.34 171.81,142.34
GND on BOTTOM (solid shape): 160.32,95.91 160.32,95.61 160.25,95.53 157.89,95.53 157.35,95 155.35,95 155.22,95.12 155.22,95.94 155.37,96.09 160.15,96.09
GND on BOTTOM (solid shape): 161.09,92.84 161.09,91.31 160.96,91.19 158.14,91.19 157.76,91.57 157.76,92.68 158.06,92.99 160.93,92.99
GND on BOTTOM (solid shape): 172.01,106.92 172.01,105.88 171.91,105.78 170.9,105.78 170.79,105.89 169.75,105.89 169.7,105.94 169.7,106.98 169.84,107.13 171.81,107.13
GND on BOTTOM (solid shape): 164.44,109.78 164.44,106.48 164.34,106.38 162.97,106.38 162.59,106.76 162.59,109.78 162.86,110.06 164.16,110.06
GND on TOP: 42.42,30.35 41.15,30.35 40.84,30.66 40.84,32.72 41.27,33.15 42.29,33.15 42.55,32.89 42.55,30.48
GND on TOP: 124.21,100.14 124.21,97.14 124.37,96.98 125.34,96.98 125.66,97.3 125.66,100.13 125.43,100.36 124.42,100.36
GND on TOP: 126.64,130.3 125.6,130.3 125.35,130.56 125.35,132.59 125.6,132.84 127.25,132.84 127.33,132.77 127.33,132.05 126.82,131.55 126.82,130.48
GND on TOP: 119.51,140.46 119.51,138.68 119.25,138.43 117.47,138.43 117.22,138.68 117.22,140.46 117.47,140.72 119.25,140.72
GND on TOP: 125.45,56.72 125.06,57.11 125.06,59.17 125.07,59.18 125.07,61.87 125.43,62.23 135.46,62.23 136.17,61.52 149.61,61.52 149.73,61.39 149.73,60.07 149.53,59.87 143.61,59.87 143.1,60.38 135.05,60.38 134.24,61.19 133.35,61.19 133.34,61.18 129.37,61.18 129.01,60.81 129.01,59.56 129.36,59.21 130.84,59.21 130.94,59.11 130.94,57.2 130.89,57.15 130.5,57.15 130.07,56.72
GND on TOP: 170.81,50.29 170.81,51.28 169.77,52.32 167.64,52.32 167.51,52.2 167.51,50.55 167.64,50.42 169.54,50.42 169.8,50.16 170.69,50.16
GND on TOP: 156.06,68.05 155.75,68.35 155.75,69.8 156.06,70.1 156.32,70.1 156.62,70.41 161.24,70.41 161.63,70.02 161.63,66.45 160.95,65.76 159.21,65.76 158.55,65.1 149.94,65.1 149.25,65.79 136.07,65.79 135.76,66.09 135.76,66.67 136.37,67.28 143.03,67.28 143.6,66.71 149.82,66.71 150.42,66.12 153.37,66.12 153.72,66.47 157.33,66.47 157.71,66.85 157.71,67.61 157.28,68.05
GND on TOP: 108.48,121.87 108.61,122 108.61,122.33 108.46,122.48 107.52,122.48 107.31,122.68 106.93,122.68 106.81,122.56 106.81,121.55 106.93,121.43 107.29,121.43 107.73,121.87
GND on TOP: 44.04,12.45 51.54,12.45 52.15,11.84 62.76,11.84 63.09,11.51 63.09,10.77 63.17,10.69 66.17,10.69 66.4,10.92 66.4,11.66 66.65,11.91 66.65,12.78 68.05,14.17 68.05,14.48 67.89,14.63 67.31,14.63 67.11,14.43 63.53,14.43 62.5,15.46 62.5,28.82 61.98,29.34 61.98,35.89 61.67,36.2 56.34,36.2 54.84,34.7 54.84,25.55 50.98,21.69 44.93,21.69 42.95,19.71 42.95,13.54
GND on TOP: 119.1,36.35 119.1,34.09 120.75,34.09 120.75,36.35
GND on TOP: 39.24,9.02 41.35,9.02 41.78,8.59 41.78,2.54 41.27,2.03 31.24,2.03 30.48,2.79 30.48,8.26 30.61,8.38 38.61,8.38
GND on TOP: 111.51,143.26 111.51,140.08 111.76,139.83 112.78,139.83 113.03,140.08 113.03,143.26 112.9,143.38 111.63,143.38
GND on TOP: 74.78,4.4 74.78,3.23 74.96,3.05 76.76,3.05 76.83,3.12 76.83,4.5 76.61,4.72 75.11,4.72
GND on TOP: 163.63,94.39 164.97,93.04 165.35,93.04 165.46,93.14 165.46,93.85 164.9,94.41 164.9,97 164.82,97.08 163.91,97.08 163.63,96.8
GND on TOP: 132.66,41.02 132.66,36.37 137.31,36.37 137.31,41.02
GND on TOP: 39.6,144.02 42.6,144.02 42.82,144.25 42.82,146.35 42.65,146.53 39.47,146.53 39.12,146.18 39.12,144.5
GND on TOP: 48.51,31.24 47.37,31.24 47.12,31.5 47.12,33.15 47.37,33.4 48.39,33.4 48.64,33.15 48.64,31.37
GND on TOP: 175.81,31.86 175.81,33.26 175.68,33.39 173.9,33.39 173.63,33.12 173.63,31.93 173.82,31.74 175.68,31.74
GND on TOP: 36.07,31.62 35.94,31.75 34.92,31.75 33.91,30.73 33.02,30.73 32.89,30.86 32.89,31.42 32.49,31.83 31.93,31.83 31.62,32.13 31.62,35.92 31.9,36.2 35.05,36.2 35.81,36.96 36.68,36.96 36.83,36.8 36.83,29.44 36.75,29.36 36.12,29.36 36.07,29.41
GND on TOP: 25.91,26.04 25.91,23.88 26.16,23.62 27.43,23.62 27.69,23.88 27.69,26.04 27.43,26.29 26.16,26.29
GND on TOP: 165.84,36.77 168.03,36.77 169.35,38.09 169.35,38.17 169.65,38.47 170.54,38.47 170.75,38.27 170.75,36.54 169.53,35.32 168.03,35.32 167.14,34.44 167.14,33.27 166.89,33.01 163.63,33.01 163.33,33.32 163.33,33.53 163.41,33.6 164.82,33.6 165.59,34.37 165.59,36.52
GND on TOP: 130.68,17.35 130.68,12.75 135.25,12.75 135.25,17.35
GND on BOTTOM: 25.65,79.48 25.65,80.85 25.76,80.95 26.7,80.95 26.85,80.8 26.85,79.5 26.7,79.35 25.78,79.35
GND on BOTTOM: 25.43,22.25 18.26,22.25 17.65,22.86 17.65,24 17.91,24.26 23.11,24.26 23.24,24.13 25.65,24.13 26.16,23.62 26.16,22.99
GND on BOTTOM: 127.38,8.89 127.38,4.45 127.13,4.19 125.73,4.19 125.48,4.45 125.48,8.76 125.73,9.02 127.25,9.02
GND on BOTTOM: 47.73,81.56 47.73,82.78 47.6,82.91 47.6,83.74 47.85,84 49.12,84 49.28,83.85 49.28,81.28 49.15,81.15 48.13,81.15
GND on BOTTOM: 77.88,33.4 79.12,33.4 79.25,33.27 79.25,31.34 79.22,31.32 79.6,30.94 80.19,30.94 80.49,30.63 80.49,29.44 80.24,29.18 78.11,29.18 77.72,29.57 77.72,33.25
GND on BOTTOM: 23.01,19.05 20.7,19.05 20.07,19.68 17.65,19.68 17.4,19.94 17.4,21.21 17.91,21.72 22.61,21.72 25.57,18.76 29.78,18.76 29.92,18.62 29.92,16.89 29.79,16.76 26.8,16.76 26.16,17.4 24.38,17.4 23.75,18.03 23.75,18.31
GND on BOTTOM: 176.45,106.55 174.98,106.55 174.7,106.83 174.7,107.26 174.85,107.42 176.53,107.42 176.66,107.29 176.66,106.76
GND on BOTTOM: 147.24,32.92 147.68,32.49 147.68,31.57 147.42,31.32 141.22,31.32 141.12,31.42 141.12,32.64 141.4,32.92
GND on BOTTOM: 27.61,77.22 28.85,77.22 29.03,77.04 29.03,75.87 28.78,75.62 27.69,75.62 25.91,75.62 25.58,75.95 25.58,77.32 25.6,77.34 25.68,77.34 25.81,77.22
GND on BOTTOM: 117.09,36.98 117.54,37.43 118.81,37.43 119,37.62 120.4,37.62 120.78,38 120.78,38.51 120.65,38.63 120.65,40.79 120.4,41.05 117.35,41.05 116.23,39.93 109.37,39.93 109.09,39.65 109.09,37.36 109.47,36.98
GND on BOTTOM: 149.99,15.62 149.99,14.2 150.22,13.97 153.87,13.97 154.05,14.15 154.05,15.62 153.92,15.75 150.11,15.75
GND on BOTTOM: 54.15,3.38 54.15,1.8 53.9,1.55 52.35,1.55 51.54,2.36 51.54,3.15 51.66,3.28 52.07,3.28 52.53,3.73 52.53,5.23 53.14,5.84 58.04,5.84 58.19,5.69 58.19,4.19 57.71,3.71 57.71,3.51 57.63,3.43 56.97,3.43 56.9,3.51 56.9,3.84 57.23,4.17 57.23,4.67 57.02,4.88 56.69,4.88 56.54,4.72 56.54,4.5 56.44,4.39 55.17,4.39
GND on BOTTOM: 28.96,68.83 25.4,68.83 25.27,68.96 25.27,70.23 25.53,70.48 29.21,70.48 29.44,70.26 29.44,69.32
GND on BOTTOM: 124.21,32.89 123.67,33.43 122.76,33.43 122.73,33.4 122.73,31.01 122.99,30.76 126.11,30.76 126.26,30.91 126.26,32.77 126.14,32.89
GND on BOTTOM: 143.28,82.02 143.28,80.29 145.01,80.29 145.01,82.02
GND on BOTTOM: 61.37,29.29 57.2,29.29 56.77,29.72 56.77,35.84 57.12,36.2 61.67,36.2 61.82,36.04 61.82,29.74
GND on BOTTOM: 120.29,31.67 118.11,31.67 117.91,31.47 117.91,30.73 118.21,30.43 120.14,30.43 120.42,30.71 120.42,31.55
GND on BOTTOM: 149.22,89.41 149.45,89.18 149.86,89.18 149.96,89.28 149.96,94.77 149.81,94.92 149.4,94.92 149.22,94.74
GND on BOTTOM: 31.01,80.87 31.01,79.81 30.96,79.76 29.01,79.76 28.73,80.04 28.73,80.92 29.08,81.28 30.61,81.28
GND on BOTTOM: 143.38,14.99 143.51,14.86 144.65,14.86 144.78,14.99 144.78,18.03 144.65,18.16 142.75,18.16 142.62,18.03 142.62,16.38 142.24,16 141.35,16 141.05,15.7 139.67,15.7 139.57,15.6 139.57,15.04 139.62,14.99
GND on BOTTOM: 112.7,131.7 112.7,126.7 117.91,126.7 117.91,131.7
GND on BOTTOM: 30.99,71.04 29.49,71.04 29.26,71.27 29.26,72.62 29.36,72.72 31.06,72.72 31.12,72.67 31.11,71.17
GND on BOTTOM: 151.49,26.67 151.49,26.11 151.69,25.91 155.45,25.91 155.6,26.06 155.6,26.67 155.35,26.92 151.74,26.92
GND on BOTTOM: 111.91,25.86 112.08,25.69 112.08,24.63 111.96,24.51 108.43,24.51 108.23,24.71 108.23,25.73 108.36,25.86
GND on BOTTOM: 147.75,38.56 147.85,38.66 147.85,39.67 147.75,39.78 144.7,39.78 144.6,39.67 144.6,38.66 144.7,38.56
GND on BOTTOM: 18.57,60.17 15.8,60.17 15.75,60.22 15.75,61.49 15.95,61.7 17.48,61.7 17.75,61.98 18.47,61.98 18.9,61.54 18.9,60.5
GND on BOTTOM: 49.07,39.34 50.6,39.34 50.88,39.06 50.88,37.85 50.7,37.67 47.85,37.67 47.78,37.74 47.78,39.24 47.88,39.34 49.07,39.34
GND on BOTTOM: 111.12,49.07 110.57,49.07 110.24,49.4 110.24,64.14 110.52,64.41 111.33,64.41 111.76,63.98 111.76,54.05 111.56,53.85 111.56,49.83 111.3,49.58 111.3,49.25
GND on BOTTOM: 159.44,53.09 159.44,50.55 159.92,50.06 163.7,50.06 164.31,50.67 164.31,53.37 164.01,53.67 163.19,53.67 162.76,53.24 159.59,53.24
GND on BOTTOM: 82.25,96.93 82.25,92.81 86.36,92.81 86.36,96.93
GND on BOTTOM: 63.2,11.43 63.2,6.1 66.4,6.1 66.4,11.43
GND on BOTTOM: 29.95,75.95 31.14,75.95 31.52,75.56 31.52,74.22 31.42,74.12 29.72,74.12 29.67,74.17 29.67,75.67
GND on BOTTOM: 114.3,32.36 115.9,32.36 116.1,32.56 116.94,32.56 117.17,32.33 117.17,30.99 116.94,30.76 114.33,30.76 114.07,31.01 114.07,32.13
GND on BOTTOM: 100.61,25.86 100.77,25.69 100.77,24.63 100.66,24.51 97.13,24.51 96.93,24.71 96.93,25.73 97.05,25.86
GND on BOTTOM: 135.7,99.88 139.85,99.88 139.92,99.95 139.92,100.95 139.8,101.06 138.84,101.06 138.08,101.82 135.56,101.82 135.55,101.83 135.31,101.83 135.24,101.75 135.24,100.35
GND on BOTTOM: 132.28,57.61 132.28,55.63 134.26,55.63 134.26,57.61
GND on BOTTOM: 145.69,19.3 144.3,19.3 142.57,21.03 141.53,21.03 140.49,22.07 139.04,22.07 138.84,22.28 138.84,23.04 139.01,23.22 140.39,23.22 140.97,22.63 144.3,22.63 144.5,22.83 144.5,25.1 144.63,25.22 145.8,25.22 145.85,25.17 145.85,22.07 145.97,21.95 145.97,19.58
GND on BOTTOM: 98.45,15.27 98.45,9.78 103.1,9.78 103.1,15.27
GND on BOTTOM: 129.41,32.38 129.41,28.22 129.01,27.81 127.69,27.81 127.53,27.97 127.53,32.08 127.94,32.49 129.31,32.49
GND on BOTTOM: 141.43,10.9 141.43,9.37 141.76,9.04 147.22,9.04 147.47,9.3 147.47,9.6 147.83,9.96 148.49,9.96 148.64,10.11 148.64,10.82 148.54,10.92 147.42,10.92 147.02,10.52 145.75,10.52 145.24,11.02 141.55,11.02
GND on BOTTOM: 136.49,89.52 136.38,89.62 131.74,89.62 131.74,89.62 130.75,89.62 130.7,89.57 130.7,88.19 130.76,88.13 135.95,88.13 136.48,88.66 136.48,89.51
GND on BOTTOM: 152.41,71.55 152.41,69.52 154.47,69.52 154.47,71.55
GND on BOTTOM, L3_SIG1, L5_SIG2, L8_SIG3, L10_SIG4: 64.36,96.93 64.36,92.81 68.48,92.81 68.48,96.93
GND on L2_GND1: outline of 106 points within 1.02,1.02 179.58,147.48 ; 4 cut-outs
GND on L5_SIG2: 82.25,96.93 82.25,93.4 82.83,92.81 86.36,92.81 86.36,96.93
GND on L6_GND2: outline of 102 points within 1.02,1.02 179.58,147.48
GND on L7_GND3: outline of 104 points within 1.02,1.02 179.58,147.48
GND on L8_SIG3: 101.65,1.02 101.65,1.75 102.13,2.24 102.13,6.22 102.31,6.4 104.67,6.4 106.55,4.52 106.55,1.85 105.72,1.02
GND on L9_PWR2: 43.48,65.99 40.23,69.24 29.64,69.24 29.13,69.75 29.13,74.24 30.2,75.31 30.2,82.14 29.36,82.98 26.75,82.98 25.95,83.78 25.95,89.65 24.94,90.65 8.08,90.65 7.72,91.01 7.72,108.17 7.76,108.22 7.76,109.08 8.89,110.21 26.26,110.21 31.34,105.13 31.34,89.64 37.97,83.01 37.97,81.53 38.4,81.1 43.18,81.1 52.43,71.86 52.43,67.51 52.25,67.34 48.46,67.34 47.12,65.99
GND on L11_GND4: outline of 84 points within 1.02,1.02 179.58,147.48
GND_3 on TOP: 107.56,123.08 107.72,122.91 108.69,122.91 108.9,123.13 108.9,124.02 108.73,124.19 107.69,124.19 107.56,124.05
GND_LAN on TOP: 176.25,33.35 176.45,33.55 178.59,33.55 179.02,33.12 179.02,11.28 179.01,11.26 179.01,9.41 178.66,9.07 173.79,9.07 173.08,9.78 173.08,12.22 173.99,13.13 173.99,27.43 173.1,28.32 173.1,30.81 173.46,31.17 176.05,31.17 176.25,31.37
GND_LAN on L8_SIG3: 154.74,30.25 175.18,30.25 176.17,29.26 176.17,8.59 175.87,8.28 154,8.28 151.61,10.67 151.61,18.41 152.27,19.08 152.27,27.79
GND_USB on BOTTOM: 172.52,141.2 172.69,141.02 174.8,141.02 175.01,140.82 175.01,131.22 175.16,131.06 179.27,131.06 179.53,131.32 179.53,141.66 178.99,142.19 173.66,142.19 173.43,142.42 172.62,142.42 172.52,142.32
VCC0V75 on TOP: 107.9,26.01 95.28,26.01 95,26.29 95,28.12 96.6,29.72 103.93,29.72 104.25,29.41 107.81,29.41 108.48,28.73 108.48,26.59
VCC0V75 on BOTTOM: 95.12,26.26 95,26.39 95,29.82 95.25,30.07 106.4,30.07 108.28,31.95 108.28,35.92 108.66,36.3 117.14,36.3 117.22,36.22 117.22,35.59 117.36,35.45 117.46,35.45 117.5,35.41 118.82,35.41 118.92,35.31 118.92,35.1 118.82,35 117.37,35 117.26,34.89 113.09,34.89 112.65,34.44 112.65,26.44 112.47,26.26
VCC0V75REF on BOTTOM: 122.2,38.53 122.2,36.25 122.07,36.12 121.06,36.12 120.93,36.25 120.93,37.64 121.18,37.9 121.18,41.33 121.44,41.58 123.09,41.58 123.34,41.33 123.34,39.04 123.09,38.79 122.45,38.79
VCC0V85 on TOP (solid shape): 124.28,21.64 124.28,19.1 124.02,18.84 107.15,18.84 106.81,19.18 106.81,21.84 107.34,22.38 123.55,22.38
VCC0V85 on BOTTOM: 34.14,52.76 32.13,52.76 32.03,52.86 32.03,55.65 32.21,55.83 34.11,55.83 34.26,55.68 34.26,52.88
VCC0V85 on BOTTOM: 28.93,81.94 28.7,82.17 28.7,82.8 29.08,83.19 31.95,83.19 32.36,82.78 32.36,81.92 32.23,81.79 31.75,81.79 31.6,81.94
VCC0V85 on L9_PWR2: 124.92,18.24 124.92,13.94 123.95,12.98 119.99,12.98 115.87,17.09 84,17.09 82.19,18.9 76.86,18.9 76.3,18.34 70,18.34 67.84,16.18 29.82,16.18 28.96,17.04 28.96,53.49 24.61,57.84 24.61,80.05 27.37,82.82 29.2,82.82 29.85,82.18 29.85,79.12 29.84,79.12 29.84,75.95 28.32,74.42 28.32,59.78 29.57,58.52 35.36,58.52 37.34,56.54 37.34,55.12 35.23,53.01 32.18,53.01 31.62,52.45 31.62,47.37 32.45,46.55 38.8,46.55 40.39,44.96 40.39,40.89 42.04,39.24 45.34,39.24 45.87,38.71 45.87,25.81 49.71,21.97 55.88,21.97 56.26,21.59 56.97,21.59 57.35,21.97 75.23,21.97 80.64,27.38 129.34,27.38 130.33,26.39 130.33,23.65
VCC1V5 on TOP: 145.03,67.69 143.61,67.69 143.13,68.17 136.4,68.17 135.89,68.68 135.89,71.88 136.27,72.26 145.08,72.26 145.14,72.21 145.14,67.79
VCC1V5 on BOTTOM: 116.81,32.92 117.13,33.24 117.12,33.25 117.12,34.29 116.97,34.44 113.21,34.44 113.08,34.31 113.08,32.74 113.16,32.66 113.92,32.66 114.17,32.92
VCC1V5 on BOTTOM: 109.37,50.01 109.37,61.37 109.12,61.62 109.12,62.56 109.37,62.81 109.37,64.77 109.14,65 107.31,65 107.09,64.77 107.09,59.59 107.67,59 107.67,58.04 107.09,57.45 107.09,50.09 107.29,49.89 109.25,49.89
VCC1V5 on L9_PWR2: 78.71,28.4 76.4,30.71 76.4,38.18 69.9,44.68 69.9,52.02 69.72,52.2 69.42,52.2 69.37,52.25 69.37,69.7 69.44,69.77 69.7,69.77 69.9,69.98 69.9,74.37 69.55,74.72 69.55,76.6 72.82,79.88 72.82,82.02 73.58,82.78 77.19,82.78 78.36,83.95 87.76,83.95 91.69,87.88 91.69,88.77 93.47,90.55 93.47,92.33 94.23,92.84 108.43,92.84 108.97,92.3 108.97,72.59 110.67,70.89 137.57,70.89 138.18,70.28 138.18,59.33 137.13,58.29 125.63,58.29 124.1,56.77 124.1,48.67 128.78,43.99 128.78,37.72 130.56,35.94 130.56,28.83 130.12,28.4
VCC1V8 on TOP (solid shape): 124.08,6.99 124.08,5.01 123.88,4.8 107.46,4.8 107.31,4.95 107.31,6.83 107.41,6.92 112.47,6.92 112.76,7.21 123.85,7.21
VCC1V8 on TOP: 49.02,33.91 45.21,33.91 45.09,34.04 45.09,35.13 45.36,35.41 48.97,35.41 49.15,35.23 49.15,34.04
VCC1V8 on TOP: 157.41,34.11 158.33,34.11 158.45,34.23 158.45,35.43 158.33,35.55 157.31,35.55 156.82,35.06 155.19,35.06 155,34.87 155,33.42 155.08,33.34 155.63,33.34 155.76,33.47 155.76,34.16 155.95,34.35 157.17,34.35
VCC1V8 on BOTTOM: 151,19.81 149.73,19.81 149.61,19.94 149.61,21.21 149.86,21.46 150.88,21.46 151.13,21.21 151.13,19.94
VCC1V8 on BOTTOM: 81.15,62.2 81.15,63.53 81.43,63.81 82.96,63.8 83.08,63.68 83.08,62.15 82.96,62.03 81.33,62.03
VCC1V8 on BOTTOM: 32.31,59.18 34.04,59.18 34.29,58.93 34.29,56.31 34.11,56.13 32.21,56.13 32.05,56.29 32.05,58.93
VCC1V8 on BOTTOM: 31.8,70.38 31.93,70.51 33.05,70.51 33.12,70.43 33.12,68.99 32.84,68.71 30.25,68.71 29.92,69.04 29.92,70.21 30.1,70.38 31.7,70.38
VCC1V8 on BOTTOM: 150.42,51.38 150.42,52.55 150.27,52.7 147.55,52.7 147.42,52.58 147.42,51.36 147.6,51.18 150.22,51.18
VCC1V8 on BOTTOM: 75.01,83.97 73.89,82.85 73.05,82.85 72.87,83.03 72.87,83.52 73.48,84.12 73.48,84.63 75.36,86.51 77.14,86.51 77.32,86.33 77.32,84.53 76.76,83.97
VCC1V8 on BOTTOM: 50.67,40.13 50.9,40.36 50.9,41.78 50.77,41.91 48.39,41.91 47.6,41.12 47.6,40.41 47.88,40.13
VCC1V8 on L5_SIG2: 84.2,61.39 81.43,61.39 80.85,61.98 80.85,64.36 81.61,65.13 81.61,69.6 79.98,71.22 78.94,71.22 73.1,77.06 73.1,84.89 74.83,86.61 77.17,86.61 84.02,79.76 84.02,66.85 84.38,66.5 84.38,61.57
VCC1V8 on L5_SIG2: 18.75,81.71 19.68,82.65 23.29,82.65 23.75,82.19 23.75,81.71 23.01,80.98 23.01,79.2 23.9,78.31 29.84,78.31 30.19,77.97 30.19,77.15 31.17,76.17 31.17,70.05 31.7,69.52 31.7,65.56 30.84,64.69 30.84,58.93 31.65,58.12 33.71,58.12 34.44,57.38 34.44,55.19 36.53,53.11 44.32,53.11 46.05,51.38 46.05,37.19 47.68,35.56 49.35,35.56 56.06,28.85 72.8,28.85 77.42,24.23 77.42,9.78 77.69,9.51 78.4,9.51 79.97,11.09 79.97,13.88 81.64,15.54 81.64,17.75 82.96,19.08 105.28,19.08 108.46,22.25 119.1,22.25 124.87,28.02 124.87,35.59 125.98,36.7 125.98,46.33 130.92,51.27 142,51.27 143.43,52.7 156.62,52.7 158.52,50.8 158.52,33.66 152.06,27.19 152.06,10.83 143.05,1.83 118.19,1.83 117.98,2.03 117.98,3.43 117.63,3.78 114.66,3.78 114.38,3.51 114.38,2.11 114.1,1.83 30.91,1.83 28.98,3.76 28.98,7.11 27.71,8.38 23.9,8.38 21.97,10.31 21.97,12.85 19.99,14.83 19.99,26.31 18.75,27.56
VCC1V8 on L8_SIG3: 69.01,69.14 66.09,69.14 65.94,69.29 65.94,76.2 67.54,77.8 69.49,77.8 71.65,79.96 72.72,79.96 73.41,80.64 73.41,82.12 73.69,82.4 76.28,82.4 76.4,82.27 76.4,81.53 73.79,78.92 72.19,78.92 69.27,76 69.27,69.39
VCC1V8 on L9_PWR2: 73.15,83.19 73.03,83.31 73.03,87.5 71.37,89.15 56.21,89.15 54.64,87.58 53.21,87.58 51.77,89.03 49.28,89.03 48.95,89.36 48.95,92.79 48.13,93.6 44.91,93.6 43.18,91.87 43.18,87.6 43.31,87.73 43.31,82.09 42.55,81.33 38.68,81.33 38.35,81.66 38.35,83.11 31.67,89.79 31.67,89.97 31.7,89.99 31.7,105.49 26.62,110.57 8.1,110.57 7.72,110.95 7.72,140.46 14.25,146.99 164.92,146.99 166.13,145.78 170.07,145.78 171.42,144.42 171.42,141.07 174.45,138.05 174.45,119.18 172.11,116.84 131.06,116.84 125.6,111.38 125.6,95.35 128.09,92.86 131.65,92.86 136.14,88.37 136.14,72.77 135.2,71.83 111.05,71.83 109.8,73.08 109.8,92.46 108.92,93.34 93.85,93.34 92.96,92.46 92.96,90.93 91.31,89.28 91.31,88.27 87.63,84.58 78.11,84.58 76.71,83.19
VCC1V8 on L10_SIG4: outline of 108 points within 25.4,25.43 134.52,95.55
VCC2V5 on TOP: 128.88,14.1 127.43,14.1 125.09,16.43 125.09,39.7 128.45,43.05 136.53,43.05 136.98,42.6 136.98,41.76 136.63,41.4 132,41.4 130.86,40.26 130.86,28.96 131.32,28.5 140.84,28.5 143.36,25.98 143.36,24.05 137.79,18.49 131.06,18.49 129.31,16.74 129.31,14.53
VCC2V5 on BOTTOM: 144.12,23.11 144.17,23.16 144.17,23.65 144.07,23.75 142.6,23.75 141.3,25.04 138.4,25.04 138.13,24.77 138.13,23.83 138.38,23.57 138.79,23.57 139.14,23.93 140.23,23.93 141.05,23.11
VCC2V5 on L3_SIG1: 148.18,8.03 144.35,11.86 144.35,16.71 141.94,19.13 139.93,19.13 138.18,20.88 138.18,24.97 138.28,25.07 149.53,25.07 155.14,30.68 170.41,30.68 173.99,27.1 173.99,23.85 173.46,23.32 168.96,23.32 167.56,21.92 167.56,17.63 168.2,16.99 173.33,16.99 173.91,16.41 173.91,8.28 173.66,8.03
VCC3_LCDBK on BOTTOM (solid shape): 84.82,144.42 84.82,140.25 84.25,139.67 82.19,139.67 81.75,140.12 81.75,144.55 82.21,145.01 84.24,145.01
VCC3V3_AUX on TOP: 79.12,1.14 78.74,1.52 78.74,2.79 79.38,3.43 81.53,3.43 82.3,2.67 89.03,2.67 89.69,3.33 89.69,6.78 89.76,6.86 94.64,6.86 94.84,6.65 94.84,1.88 94.11,1.14
VCC3V3_AUX on BOTTOM: 90.93,100.97 90.93,99.75 90.7,99.52 88.8,99.52 88.6,99.72 88.6,100.97 88.77,101.14 90.75,101.14
VCC3V3_AUX on BOTTOM: 148.06,19.13 146.91,19.13 146.43,19.61 146.43,23.14 146.15,23.42 146.15,23.65 146.25,23.75 148.16,23.75 148.41,23.5 148.41,19.48
VCC3V3_AUX on BOTTOM: 72.82,89.59 74.12,89.59 74.42,89.89 74.42,91.06 74.17,91.31 72.9,91.31 72.77,91.19 72.77,89.64
VCC3V3_AUX on BOTTOM: 82.19,138.91 84.15,138.91 84.48,138.58 84.48,136.91 84.28,136.7 82.25,136.7 82.04,136.91 82.04,138.76
VCC3V3_AUX on BOTTOM: 147.07,13.97 147.07,12.95 147.19,12.83 147.83,12.83 147.96,12.95 147.96,13.97 147.83,14.1 147.19,14.1
VCC3V3_AUX on BOTTOM: 25.15,80.8 25.15,79.22 25.27,79.09 25.27,77.67 25.2,77.6 24.08,77.6 23.95,77.72 23.95,80.72 24.16,80.92 25.02,80.92
VCC3V3_AUX on BOTTOM: 123.69,34.68 123.34,34.34 121.01,34.34 120.9,34.24 120.9,34.16 121.18,33.88 124.1,33.88 124.41,33.58 125.98,33.58 126.29,33.88 126.29,35.76 126.11,35.94 123.77,35.94 123.69,35.85
VCC3V3_AUX on L4_PWR1: outline of 155 points within 7.85,1.02 179.4,146.94
VCC3V3_AUX on L5_SIG2: 15.44,1.19 12.32,1.19 11.94,1.57 11.94,4.37 10.85,5.46 2.16,5.46 1.45,6.17 1.45,66.55 2.46,67.56 11.56,67.56 12.22,68.22 12.22,84.86 12.88,85.52 26.52,85.52 27.43,84.61 27.43,79.58 26.87,79.02 24.08,79.02 23.62,79.48 23.62,80.64 24.26,81.28 24.26,82.6 23.65,83.21 19.13,83.21 17.65,81.74 17.65,15.54 21.34,11.86 21.34,9.07 19.91,7.65 15.7,7.65 15.62,7.57 15.62,1.37
VCC3V3_AUX_F1 on BOTTOM: 90.88,97.23 90.73,97.08 88.09,97.08 87.71,97.46 87.71,97.87 87.1,98.48 81.08,98.48 80.72,98.12 80.72,91.74 81.1,91.36 87.25,91.36 87.68,91.8 87.68,96.82 87.76,96.9 88.85,96.9 88.98,96.77 88.98,91.54 87.58,90.14 86.44,90.14 85.98,90.6 84.2,90.6 83.77,90.17 80.37,90.17 79.38,91.16 79.38,94.67 80.21,95.5 80.21,99.03 80.37,99.19 88.09,99.19 88.77,98.5 90.78,98.5 90.88,98.4
VCC3V3_AUX_F2 on BOTTOM: 71.37,89.28 69.62,89.28 68.88,90.02 62.61,90.02 61.32,91.31 61.32,95.73 62,96.42 62,98.86 62.87,99.72 64.01,99.72 64.14,99.59 64.14,98.53 64.01,98.4 63.27,98.4 62.66,97.79 62.66,91.82 63.12,91.36 69.62,91.36 69.75,91.49 69.75,98.81 69.88,98.93 71.2,98.93 71.22,98.91 71.22,94.31 71.04,94.13 71.04,92.63 71.5,92.18 71.5,89.41
VCC3V3_MP on TOP: 109.35,137.67 109.63,137.39 110.62,137.39 111,137.77 111,143.26 110.87,143.38 109.47,143.38 109.35,143.26
VCC3V3_MP on L4_PWR1: 130.38,60.15 115.6,60.15 112.44,63.31 112.44,65.13 113.77,66.46 113.77,72.72 110.69,75.79 110.69,77.11 106.25,81.56 101.6,81.56 101.14,82.02 101.14,95.3 100.78,95.66 100.78,104.39 104.5,108.1 104.5,119.84 103.45,120.88 103.45,127.17 105.89,129.62 108.03,129.62 108.89,130.48 108.89,132.46 107.75,133.6 93.07,133.6 88.22,138.46 76.5,138.46 75.13,137.08 75.13,136.02 71.17,132.05 71.17,112.83 70,111.66 67.39,111.66 66.42,112.62 66.42,139.73 69.42,142.72 69.42,145.85 70.82,147.24 165.3,147.24 165.74,146.81 165.74,146.33 165.84,146.23 172.62,146.23 173.53,145.31 173.53,141.07 174.6,140 174.6,131.22 175.01,130.81 179.27,130.81 179.27,122.99 178.71,122.43 124.49,122.43 123.01,120.95 117.83,120.95 116.94,120.07 109.98,120.07 109.02,119.1 109.02,112.6 110.57,111.04 111.61,111.04 111.93,110.73 111.93,104.99 109.88,102.94 109.88,98.25 112.52,95.61 125.07,95.61 136.03,84.64 136.03,80.76 135.1,79.83 135.1,64.87
VCC3V3_MP_ALT on TOP: 124.54,139.88 124.84,139.57 124.84,133.73 125.09,133.48 126.62,133.48 127,133.86 127,139.45 127.33,139.78 127.33,141.5 127.29,141.54 121.32,141.54 120.27,140.49 120.27,137.79 120.52,137.54 121.92,137.54 122.11,137.73 122.11,139.64 122.35,139.88
VCC3V3_MP_ALT on L8_SIG3: 123.6,145.92 129.82,145.92 131.06,144.68 131.06,143.92 130.53,143.38 130.07,143.38 125.04,138.35 125.04,130.96 124.82,130.73 123.75,130.73 123.33,131.15 121.78,131.15 119.81,133.12 119.81,140.49 122.35,143.03 122.35,144.68
VCC3V3_PCIE on BOTTOM: 17.42,64.31 18.77,64.31 18.8,64.29 18.8,62.76 18.36,62.33 12.88,62.33 12.62,62.59 12.62,63.47 13.21,64.06 17.17,64.06
VCC3V3_PCIE on BOTTOM: 27.15,66.83 25.32,66.83 25.07,67.08 25.07,68.3 25.1,68.33 28.32,68.33 28.57,68.58 29.41,68.58 29.59,68.4 29.59,67.64 29.24,67.28 27.61,67.28
VCC5V on TOP: 141.05,59.59 143.15,59.59 143.31,59.44 149.17,59.44 149.43,59.18 149.43,55.95 148.11,54.63 141.07,54.63 141.03,54.68 141.03,59.57
VCC5V on TOP: 161.86,35.02 161.96,34.92 161.96,34.61 162.01,34.56 164.22,34.56 164.55,34.89 164.55,36.11 164.65,36.21 165.13,36.21 165.2,36.14 165.2,34.54 164.64,33.99 163.12,33.99 162.28,33.15 162.28,31.17 162.1,30.99 160.88,30.99 160.63,31.24 160.63,34.92 160.73,35.02
VCC5V on BOTTOM: 17.53,17.53 17.53,18.52 18.26,19.25 19.61,19.25 20.32,18.54 21.34,18.54 21.62,18.26 22.89,18.26 23.37,17.78 23.37,17.14 23.62,16.89 25.4,16.89 26.75,15.54 34.92,15.54 35.1,15.37 35.1,13.08 34.9,12.88 22.17,12.88
VCC5V on L5_SIG2: 171.15,30.99 160.88,30.99 159.59,32.28 159.59,51.87 158.34,53.11 142.24,53.11 141.17,52.04 130.61,52.04 130.43,51.87 128.96,51.87 128.14,52.68 128.14,64.62 130.4,66.88 162.93,66.88 173.05,56.76 173.05,32.89
VCC5V on L9_PWR2: 146.71,57.15 146.71,63.12 151.74,68.15 157.45,68.15 158.95,69.65 163.19,69.65 165.53,71.98 165.53,75.56 164.54,76.56 137.97,76.56 137.49,77.04 137.49,89.03 132.66,93.85 128.14,93.85 126.87,95.12 126.87,110.24 132.46,115.82 173.33,115.82 174.17,114.99 174.17,95.35 174.42,95.1 177.37,95.1 178.44,94.03 178.44,71.96 176.1,69.62 176.1,32.31 174.35,30.56 156.92,30.56 155.98,31.5 155.98,51.89 151.28,56.59 147.27,56.59
VCC5V on L10_SIG4: 137.44,8.48 146.08,17.12 146.08,22.2 159.05,35.18 163.53,35.18 164.03,34.67 164.03,31.04 157.68,24.69 154.15,24.69 151.36,21.89 151.36,13.06 141.78,3.48 34.01,3.48 30.07,7.42 30.07,14.35 30.3,14.58 33.96,14.58 38.43,10.11 57.35,10.11 58.83,11.58 66.9,11.58 70,8.48
VCC12 on TOP: 124.13,52.12 127.94,52.12 128.45,51.61 128.45,48.79 127.99,48.34 124.08,48.34 123.77,48.64 123.77,51.77
VCC12 on TOP: 129.06,129.92 129.97,129.92 130.18,129.72 130.18,129.06 130.02,128.91 128.93,128.91 128.78,129.06 128.78,129.64
VCC12 on TOP: 26.29,15.49 41.53,15.49 41.83,15.19 41.83,10.46 41.53,10.16 39.5,10.16 38.23,11.43 35.56,11.43 34.04,9.91 30.2,9.91 28.75,8.46 25.81,8.46 24.99,9.27 24.99,14.2
VCC12 on TOP: 159.77,72.9 164.34,72.9 164.62,73.18 164.62,74.83 164.41,75.03 159.77,75.03 159.46,74.73 159.46,73.2
VCC12 on BOTTOM: 25.78,25.15 22.99,25.15 22.61,24.77 17.78,24.77 17.53,25.02 17.53,26.92 17.78,27.18 25.15,27.18 26.04,26.29 26.04,25.4
VCC12 on BOTTOM: 79.73,18.15 79.73,13.35 79.38,12.99 77.55,12.99 77.09,13.45 77.09,18.22 77.62,18.76 79.12,18.76
VCC12 on BOTTOM: 40.16,8.13 41.48,8.13 41.81,8.46 41.81,15.27 41.48,15.6 38.73,15.6 37.97,14.83 38,14.81 38,8.81 38.71,8.1 40.13,8.1
VCC12 on L9_PWR2: 11.94,1.04 11.84,1.14 11.84,4.17 10.64,5.36 1.22,5.36 1.07,5.51 1.07,67.79 1.47,68.2 11.07,68.2 11.91,69.04 11.91,85.04 10.77,86.18 7.95,86.18 7.77,86.36 7.77,89.48 7.91,89.48 8.58,90.15 25.03,90.15 25.55,89.63 25.55,81.61 24.05,80.11 24.05,57.76 28.32,53.49 28.32,16.64 29.34,15.62 68.02,15.62 70.21,17.81 76.68,17.81 77.19,18.31 82.12,18.31 83.79,16.64 115.27,16.64 119.41,12.5 125.63,12.5 126.11,12.98 126.11,18.69 131.19,23.77 131.19,36.07 129.29,37.97 129.29,44.22 124.71,48.79 124.71,56.54 125.96,57.78 137.74,57.78 139.19,59.23 139.19,74.88 139.62,75.31 164.21,75.31 164.97,74.55 164.97,72.36 162.94,70.33 158.42,70.33 156.95,68.86 151.69,68.86 146.1,63.27 146.1,57.15 147.29,55.96 148.82,55.96 153.25,51.52 153.25,44.67 147.96,39.37 147.96,4.7 144.3,1.04 125.65,1.04 125.5,1.19 125.5,3.4 125.3,3.61 122.53,3.61 122.3,3.38 122.3,1.3 122.05,1.04
VCC12_AMC on TOP, BOTTOM, L5_SIG2, L8_SIG3, L10_SIG4: 15.75,1.65 15.75,7.06 16.1,7.42 27.48,7.42 28.02,6.88 28.02,1.63 27.69,1.3 16.1,1.3
VCC12_AMC on L4_PWR1: 12.27,1.02 11.84,1.45 11.84,4.09 10.62,5.31 1.57,5.31 1.04,5.84 1.04,67.72 1.52,68.2 11.35,68.2 12.75,66.8 18.34,66.8 19.53,65.61 19.53,59.26 20.65,58.14 20.65,23.04 22.68,21.01 26.77,21.01 30,17.78 30,1.07 29.95,1.02
VCCPLLA1B on TOP (solid shape): 69.6,104.37 69.6,103.48 69.24,103.12 69.24,100.86 69.11,100.74 68.81,100.74 68.8,100.73 68.8,97.91 68.73,97.84 68.55,97.84 68.53,97.86 68.53,98.91 68.52,98.92 68.31,98.92 68.3,98.91 68.3,97.87 68.27,97.84 68.07,97.84 68.04,97.87 68.04,104.55 69.42,104.55
VCCPLLA2B on TOP (solid shape): 87.48,104.55 87.48,103.68 87.15,103.35 87.15,100.18 86.69,99.72 86.69,97.94 86.61,97.86 86.49,97.86 86.42,97.94 86.42,98.95 86.39,98.98 86.21,98.98 86.19,98.97 86.19,97.93 86.12,97.86 85.99,97.86 85.92,97.93 85.92,98.92 86.11,99.11 86.11,104.14 86.54,104.57 87.45,104.57
VDD33 on BOTTOM: 29.77,76.45 29.53,76.7 29.53,77.38 29.29,77.62 25.6,77.62 25.55,77.67 25.55,78.87 25.6,78.92 27.53,78.92 27.94,79.32 32.59,79.32 32.97,78.94 32.97,76.58 32.84,76.45
VDD33 on BOTTOM: 49.99,81.25 49.99,83.79 50.15,83.96 51.07,83.96 51.08,83.97 51.27,83.78 51.27,80.1 51.19,80.02 49.52,80.02 49.48,80.06 49.48,80.75
VDD33 on L3_SIG1: 30.43,80.54 30.43,77.37 31.79,76.01 33.01,76.01 33.73,75.29 46.91,75.29 48.01,76.38 48.01,80.34 47.29,81.05 47.29,84.3 46.94,84.66 45.26,84.66 43.26,82.65 32.54,82.65
VDD33 on L5_SIG2: 59.59,66.37 58.01,66.37 57.89,66.24 57.89,65.15 57.78,65.05 49.56,65.05 49.33,64.82 39.55,64.82 37.06,67.31 35.71,67.31 34.34,68.68 32.36,68.68 32.21,68.53 32.21,65.13 33.73,63.6 35,63.6 35.64,62.97 46.3,62.97 46.58,63.25 59.39,63.25 59.66,63.53 59.66,66.29
VDD33 on L9_PWR2: 53.47,86.49 51.66,88.29 51.66,88.32 51.49,88.49 49.2,88.49 48.56,89.13 48.56,92.46 47.88,93.14 45.11,93.14 43.66,91.69 43.66,85.42 43.41,85.17 43.41,81.78 50.29,74.91 52.37,74.91 53.47,76.01
VDD33 on L10_SIG4: 33.86,67.67 33.86,75.59 32.28,77.17 32.28,78.26 31.11,79.43 28.12,79.43 27.91,79.22 27.91,77.65 28.07,77.5 28.98,77.5 29.26,77.22 29.26,67.26 29.74,66.78 32.97,66.78
VDD_USB_0 on L10_SIG4: 63.42,64.92 60.4,64.92 60.27,65.05 60.27,68 60.53,68.25 60.91,68.25 61.09,68.43 61.09,74.8 59.31,76.58 59.31,85.22 60.05,85.95 62.13,85.95 62.59,85.5 62.59,78.99 63.7,77.88 63.7,70.76 63.42,70.48 63.09,70.48 62.87,70.26 62.87,67.59 63.02,67.44 63.47,67.44 63.65,67.26 63.65,65.15
VDD_USB_1 on L5_SIG2: 64.39,66.34 64.44,66.29 64.44,57.84 64.29,57.68 40.23,57.68 39.8,58.12 39.8,59.28 40.42,59.91 47.97,59.91 48.34,60.27 62.23,60.27 62.69,60.73 62.69,66.32 62.71,66.34
VDDAHV on BOTTOM: 33.96,59.72 32.23,59.72 31.98,59.97 31.98,62.59 32.16,62.76 34.06,62.76 34.21,62.61 34.21,59.97
VDDAHV on L9_PWR2: 43.13,65.01 47.33,65.01 48.96,66.65 52.73,66.65 52.96,66.42 52.96,55.37 52.88,55.3 40.26,55.3 40.13,55.42 39.09,55.42 35.55,58.97 31.46,58.97 31.45,58.97 30.1,58.97 28.86,60.21 28.86,66.04 29.92,67.11 31.27,67.11 32.68,68.52 39.62,68.52
VDDALV on BOTTOM: 32.28,52.27 34.01,52.27 34.27,52.02 34.26,49.4 34.08,49.22 32.18,49.23 32.03,49.38 32.03,52.02
VDDALV on L9_PWR2: 52.86,45.9 54.86,47.9 54.86,54.31 55.04,54.48 55.35,54.48 55.4,54.53 55.4,56.97 55.32,57.05 55.04,57.05 54.86,57.23 54.86,57.48 55.07,57.68 55.35,57.68 55.42,57.76 55.42,58.57 55.35,58.65 55.02,58.65 54.86,58.8 54.86,59.13 55.02,59.28 55.32,59.28 55.4,59.36 55.4,60.99 55.35,61.04 55.07,61.04 54.86,61.24 54.86,61.49 55.04,61.67 55.32,61.67 55.42,61.77 55.42,62.53 55.32,62.64 55.04,62.64 54.86,62.81 54.86,63.12 55.04,63.3 55.3,63.3 55.42,63.42 55.42,64.14 55.32,64.24 55.04,64.24 54.86,64.41 54.86,64.69 55.04,64.87 55.32,64.87 55.42,64.97 55.42,65.74 55.32,65.84 55.04,65.84 54.86,66.01 54.86,66.32 55.02,66.47 55.32,66.47 55.42,66.57 55.42,67.34 55.32,67.44 54.97,67.44 54.86,67.54 54.86,68.17 54.79,68.25 53.31,68.25 53.16,68.1 53.16,54.74 53.09,54.66 50.06,54.66 49.66,55.07 44.3,55.07 43.05,53.82 36.81,53.82 35.31,52.32 32.64,52.32 32.21,51.89 32.21,47.8 32.99,47.02 39.37,47.02 40.49,45.9
VDDPLL0 on BOTTOM: 80.62,63.7 80.62,62.26 80.39,62.03 78.89,62.03 78.77,62.15 78.77,63.68 78.89,63.8 80.52,63.8
VDDPLL0 on L8_SIG3: 69.9,55.91 69.72,56.08 69.34,56.08 69.09,56.34 68.4,56.34 67.51,57.23 67.51,65.56 67.79,65.84 68.94,65.84 69.11,66.01 69.11,68.73 69.34,68.96 71.42,68.96 71.65,68.73 71.65,66.78 73.38,65.05 80.01,65.05 80.67,64.39 80.67,63.3 79.04,61.67 72.54,61.67 70.82,59.94 70.82,57.12 70.92,57.02 71.53,57.02 71.65,56.9 71.65,53.95 71.37,53.67 70.05,53.67 69.9,53.82
CVDD on TOP: 63.83,28.65 63.83,14.94 63.88,14.88 66.88,14.88 67.11,15.11 69.72,15.11 70.43,15.82 70.43,17.48 70.51,17.55 76.16,17.55 76.27,17.66 76.27,35.97 76.07,36.17 63.07,36.17 62.8,35.9 62.8,29.69
CVDD on BOTTOM: 63.35,29.29 62.94,29.69 62.94,36.04 63.22,36.32 73.38,36.32 73.41,36.3 73.41,29.95 72.75,29.29
CVDD on L3_SIG1: 45.39,37.49 55.52,47.62 55.52,74.73 54.74,75.51 54.74,87.05 56.54,88.85 70.89,88.85 72.57,87.17 72.57,78.21 69.24,74.88 69.24,47.52 75.36,41.4 75.36,23.09 74.83,22.56 49,22.56 45.39,26.16
CVDD on L4_PWR1: 72.16,88.65 72.57,88.24 72.57,78.21 69.24,74.88 69.24,47.52 75.97,40.79 75.97,23.7 74.19,21.92 23.39,21.92 21.34,23.98 21.34,58.37 20.12,59.59 20.12,65.74 18.75,67.11 12.9,67.11 11.86,68.15 11.86,86.79 12.01,86.94 43.28,86.94 44.98,88.65
CVDD on L6_GND2: 58.6,68.91 58.78,69.09 58.78,76.35 54.74,80.39 54.74,87.05 56.49,88.8 70.94,88.8 72.57,87.17 72.57,78.21 68.99,74.63 68.99,45.92 68.76,45.69 59.92,45.69 57.2,48.41 57.2,50.19 55.07,52.32 49.17,52.32 46.63,49.78 46.63,37.92 49.2,35.36 63.42,35.36 64.44,36.37 73.03,36.37 74.83,34.57 74.83,27.69 68.25,21.11 39.37,21.11 30.61,29.87 30.61,61.49 33.1,63.98 48.06,63.98 48.31,63.73 49.15,63.73 49.4,63.98 53.64,63.98 54.1,64.44 54.1,68.76 54.25,68.91
CVDD on L9_PWR2: 46.61,44.83 47.12,45.34 53.24,45.34 55.55,47.65 55.55,69.72 54.86,69.72 54.74,69.85 54.74,75.95 54.61,76.07 54.61,86.92 56.34,88.65 71.09,88.65 72.57,87.17 72.57,80 69.19,76.62 69.19,44.96 75.97,38.17 75.97,23.75 74.78,22.56 49.66,22.56 46.61,25.6
CVDD1 on TOP: 80.62,19.99 88.52,19.99 89.38,19.13 89.38,18.75 89.36,18.72 89.36,17.7 89.53,17.53 94.46,17.53 94.74,17.81 94.74,20.6 91.52,23.83 80.59,23.83 80.44,23.67 80.44,20.17
CVDD1 on BOTTOM: 74.68,33.45 74.68,27.3 75.13,26.85 78.21,26.85 78.56,27.2 78.56,28.24 78.05,28.75 77.55,28.75 77.06,29.24 77.06,31.19 76.91,31.34 76.91,33.43 76.71,33.63 74.85,33.63
CVDD1 on L8_SIG3: 55.94,21.17 55.5,21.62 55.5,67.82 55.93,68.25 57.81,68.25 58.01,68.05 58.01,66.67 58.06,66.62 59.36,66.62 59.66,66.32 59.66,65.23 59.87,65.02 64.31,65.02 64.47,65.18 64.47,67.82 64.67,68.02 66.09,68.02 67.39,66.73 67.39,56.64 67.94,56.08 69.01,56.08 69.22,55.88 69.22,38.3 78.87,28.65 90.45,28.65 90.86,28.24 90.86,21.76 90.27,21.17
DDR_DVDD18 on TOP (solid shape): 142.37,93.7 142.37,91.06 142.09,90.78 139.73,90.78 139.6,90.91 139.6,93.7 139.83,93.93 142.14,93.93
DDR_DVDD18 on BOTTOM (solid shape): 144.65,98.7 144.65,96.27 141.2,92.81 141.2,91.06 141.12,90.98 139.62,90.98 138.94,91.67 138.94,93.37 142.98,97.41 142.98,97.87 142.62,98.22 142.44,98.22 142.37,98.3 142.37,98.78 142.49,98.91 144.45,98.91
PLL0_VDDA12 on BOTTOM (solid shape): 161.98,94.08 161.9,94.01 160.99,94.01 160.45,93.47 160.45,93.45 158.27,93.45 157.84,93.88 157.84,94.49 158.25,94.91 161.98,94.91
SATA_GND on TOP: 23.75,16.84 24.13,16.46 40.21,16.46 40.64,16.89 40.64,19.3 39.78,20.17 38.35,20.17 37.59,19.41 37.59,18.47 37.26,18.14 28.22,18.14 27.51,18.85 27.51,21.89 26.54,22.86 25.65,22.86 25.02,23.5 25.02,25.78 24.77,26.04 23.88,26.04 23.75,25.91
TRIP1 on TOP (solid shape): 164.92,146.91 164.92,143.89 164.8,143.76 154.13,143.76 153.64,144.25 153.64,147.04 154.38,147.78 164.06,147.78
TRIP2 on BOTTOM (solid shape): 39.55,148.16 39.55,147.24 39.37,147.07 36.25,147.07 35.97,146.79 35.97,144.45 35.71,144.2 34.44,144.2 34.09,144.55 34.09,146.86 33.86,147.09 29.49,147.09 29.39,147.19 29.39,148.16 29.44,148.21 39.5,148.21
TRIP2 on TOP: 37.36,146.56 34.37,146.56 34.14,146.33 34.14,144.22 34.32,144.04 37.49,144.04 37.85,144.4 37.85,146.08
USB0_0V85 on BOTTOM: 31.55,81.28 32.26,81.28 32.36,81.18 32.36,80.21 32.23,80.09 31.55,80.09 31.42,80.21 31.42,81.15
USB0_0V85 on L5_SIG2: 61.26,67.41 60.78,67.41 60.1,68.1 56.64,68.1 56.46,67.92 56.46,67.51 56.24,67.28 44.3,67.28 32.36,79.22 31.45,79.22 30.86,79.81 30.86,81.48 31.24,81.86 32.28,81.86 42.21,71.93 46.53,71.93 50.22,68.25 55.37,68.25 55.47,68.35 55.47,68.81 55.66,69 56.63,69 56.67,69.04 62.56,69.04 62.66,68.94 62.66,68.5 62.47,68.31 62.17,68.31
USB0_VDD3V3 on L5_SIG2: 60.25,66.73 60.25,67.28 60.1,67.44 56.57,67.44 56.3,67.17 56.3,66.76 56.18,66.65 49.25,66.65 48.82,66.22 48.21,66.22 47.68,66.75 44.04,66.75 34.77,76.02 32.44,76.02 31.52,75.11 31.52,72.47 35.79,68.2 39.42,68.2 39.71,67.91 39.71,66.56 41.15,65.13 48.79,65.13 49.35,65.68 57.15,65.68 57.25,65.79 57.25,66.4 57.4,66.55 60.07,66.55
USB0_VDDA33 on BOTTOM: 161.93,96.52 162.81,97.41 162.81,99.29 162.76,99.34 160.63,99.34 159.84,98.55 155.57,98.55 153.57,100.55 152.24,100.55 151.85,100.16 151.85,96.79 152.12,96.52
USB0VBUS on BOTTOM: 157.94,56.49 157.94,53.62 158.06,53.49 159.16,53.49 159.79,54.13 164.31,54.13 164.59,54.41 164.59,57.3 164.41,57.48 158.93,57.48
USB1_0V85 on L8_SIG3: 63.3,67.06 61.54,67.06 61.11,67.49 61.11,74.47 63.88,77.24 63.88,80.98 65.23,82.32 72.59,82.32 72.87,82.04 72.87,80.67 72.42,80.21 69.42,80.21 65.2,76 65.2,69.29 65,69.09 64.64,69.09 64.24,68.68 64.24,68.53 63.98,68.28 63.83,68.28 63.42,67.87 63.42,67.18
USB1_VDD3V3 on L5_SIG2: 64.44,67.31 64.3,67.45 61.83,67.45 61.37,66.98 61.37,66.29 60.93,65.86 60.55,65.86 60.3,65.61 60.3,62.74 60.17,62.61 46.53,62.61 46.41,62.48 40.61,62.48 39.47,61.34 38.81,61.34 37.67,62.48 35.18,62.48 34.52,63.14 33.63,63.14 32.08,64.69 31.57,64.69 31.32,64.44 31.32,59.49 32.46,58.34 33.99,58.34 34.71,57.62 34.71,55.54 35.84,54.41 38.2,54.41 38.84,55.04 38.84,57.25 39.52,57.94 39.52,59.77 39.98,60.22 47.82,60.22 48.37,60.78 61.75,60.78 62.05,61.09 62.05,66.34 62.18,66.47 64.34,66.47 64.44,66.57
USB1VBUS on TOP: 153.93,35.91 153.93,34.13 154.06,34 154.44,34 154.57,34.13 154.57,34.97 155.04,35.44 155.9,35.44 157.67,37.2 157.67,38.21 158.7,39.24 164.3,39.24 164.5,39.04 164.5,37.99 164.74,37.74 165.44,37.74 166.14,38.45 169.05,38.45 169.55,38.96 170.81,38.96 171.8,37.97 175.56,37.97 175.79,38.2 175.79,38.68 175.72,38.76 172.95,38.76 171.07,40.64 157.02,40.64 155.35,38.96 155.35,36.61 154.77,36.04 154.06,36.04
USB_SHIELD on TOP: 176.43,49.53 171.96,49.53 171.83,49.66 171.83,51.16 169.88,53.11 169.88,64.01 166.51,67.37 166.51,69.13 167.6,70.22 170.17,70.22 172.3,68.08 177.71,68.08 179.21,66.59 179.21,35.06 178.83,34.68 176.99,34.68 176.68,34.99 176.68,49.28
USB_VBUS on TOP (solid shape): 164.57,140.18 164.57,139.24 164.29,138.96 164.01,138.96 163.83,138.79 163.83,137.39 163.75,137.31 163.63,137.31 163.55,137.39 163.55,140.21 163.65,140.31 164.44,140.31
USB_VBUS on BOTTOM: 168.15,130.84 168.3,130.99 168.3,133.07 168.1,133.27 166.85,133.27 166.66,133.08 166.66,130.9 166.73,130.84
USB_VBUS_R on BOTTOM: 170.31,135.46 172.26,135.46 172.39,135.33 172.39,134.52 171.73,133.86 171.2,133.86 170.69,133.35 170.69,130.99 170.54,130.84 168.81,130.84 168.71,130.94 168.71,133.27 168.15,133.83 168.15,134.37 168.28,134.49 169.34,134.49
USB_VIO on TOP (solid shape): 167.89,139.7 167.89,137.62 167.77,137.49 166.75,137.49 165.74,136.47 164.57,136.47 164.49,136.55 164.49,137.08 164.57,137.16 165.2,137.16 166.75,138.71 166.75,139.7 166.85,139.8 167.79,139.8
USB_VIO on BOTTOM: 162.18,141.68 162.18,140.97 163.07,140.08 166.47,140.08 166.73,139.83 166.73,137.77 166.95,137.54 167.82,137.54 167.89,137.62 167.89,138.15 167.72,138.33 167.72,140.97 167.59,141.1 163.96,141.1 163.09,141.96 162.46,141.96
VPP1V8 on TOP: 80.39,70.03 92.89,70.03 93.19,69.72 93.19,68.68 92.96,68.45 80.37,68.45 79.96,68.86 79.96,69.6
VPP1V8 on L5_SIG2: 79.6,64.87 80.75,66.01 80.75,69.65 80.54,69.85 78,69.85 75.54,67.39 70.21,67.39 69.98,67.16 69.98,66.88 69.75,66.65 68.76,66.65 68.33,67.08 68.33,67.97 68.15,68.15 67.92,68.15 67.49,67.72 67.49,67.61 67.31,67.44 66.95,67.44 66.85,67.54 66.85,67.74 66.45,68.15 66.12,68.15 65.91,67.94 65.91,65.13 66.17,64.87
XDS_1V2 on TOP (solid shape): 138.95,79.11 138.95,77.6 138.73,77.39 132.26,77.39 132.21,77.44 132.21,79.12 132.33,79.25 138.81,79.25
XDS_1V2 on BOTTOM: 163.35,95.12 163.35,92.68 163.5,92.53 164.97,92.53 165.13,92.68 165.13,95 164.87,95.25 163.47,95.25
XDS_1V2 on BOTTOM: 135.98,86.15 136.56,86.73 136.56,87.35 136.18,87.73 130.94,87.73 130.76,87.55 130.76,86.29 130.9,86.14 130.91,86.15
