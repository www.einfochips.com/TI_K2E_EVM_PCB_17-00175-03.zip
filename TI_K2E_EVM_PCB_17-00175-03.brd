# Allegro board TI_K2E_EVM_PCB_17-00175-03.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UEMU0: length 6.2
  TOP w0.152: U9.33 119.33,104.8 119.6,104.53 120.89,104.53 121.31,104.12 121.31,102.03 120.88,101.6 R115.1
UEMU1: length 4.1
  TOP w0.152: R116.1 120.75,103.91 120.61,104.05 119.39,104.05 118.52,104.93 U9.32
UEXP0: length 2.6
  TOP w0.152: U9.29 116.13,104.47 116.56,104.04 R119.1
UEXP1: length 2.5
  TOP w0.152: R120.1 115.16,104.37 115.34,104.55 U9.28
UEXP2: length 2.8
  TOP w0.152: U9.27 114.53,104.62 113.77,103.86 R121.1
UEXP3: length 3.6
  TOP w0.152: U9.23 111.33,105.03 111.18,104.88 110.52,104.88 109.58,103.94 R124.1
URTCK: length 5.9
  TOP w0.152: U9.22 v1(111.33,107.65)
  BOTTOM w0.152: v1(111.33,107.65) 111.33,104.98 110.87,104.52 R383.1
URTM_PS#: length 98.6
  TOP w0.152: v1(76.6,117.89) U8.28 ; v3(15.98,82.52) 16.41,82.96 16.41,83.72 16.25,83.88 R188.1 R189.2
  L8_SIG3 w0.107: v3(15.98,82.52) 17.29,83.84 26.08,83.84 27.75,85.51 27.75,111.01 36.65,119.91 40.77,119.91 41.35,120.5 43.1,120.5 43.4,120.21 52.48,120.21 52.6,120.09 53.37,120.09 54.06,120.78 63.96,120.78 65.66,119.07 75.41,119.07 76.15,118.34 v1(76.6,117.89)
URTM_PS#_R: length 2.2
  TOP w0.152: R189.1 14.35,85.75 J4.C1
USB0_0V85: length 1.9
  TOP w0.254: U23.U8 v6(62.38,68.56) ; U23.V9 v6(60.78,67.76)
  BOTTOM w0.254: C505.1 v6(60.78,67.76) ; C504.1 v6(62.38,68.56)
  vias: v5(31.75,80.39)
USB0_ID: length 2.2
  TOP w0.254: U23.W4 v6(59.98,71.76)
  BOTTOM w0.152: 60.38,72.17 R431.2
  BOTTOM w0.165: v6(59.98,71.76) 60.38,72.17
USB0_RXN: length 145.3
  TOP w0.114: L7.2 157.41,59.79 arc(156.96,60.09) 156.44,60.19 154.33,60.19 arc(153.79,60.42) 153.57,60.96 153.57,61.19 arc(152.89,62.82) 151.26,63.5 149.44,63.5 arc(148.68,63.65) 148.03,64.08 arc(147.83,64.22) 147.6,64.26 130.51,64.26 arc(127.44,64.87) 124.83,66.61 124.17,67.28 arc(123.63,67.64) 122.99,67.77 121.87,67.77 arc(120.27,68.43) 119.61,70.03 119.61,92.79 arc(117.99,96.7) 114.07,98.32 102.74,98.32 arc(101.15,98.01) 99.8,97.1 99.69,97 arc(98.54,96.23) 97.18,95.96 94.49,95.96 arc(92.84,95.28) 92.15,93.62 92.15,87.82 arc(91.14,85.37) 88.68,84.35 64.59,84.35 arc(63.28,83.81) 62.74,82.5 62.74,75.1 arc(62.69,74.88) 62.57,74.69 arc(62.53,74.65) 62.51,74.6 arc(62.49,74.55) 62.49,74.5 62.49,74.45 arc(62.48,74.27) 62.44,74.1 arc(62.48,73.87) 62.69,73.76 U23.T1
USB0_RXP: length 145.3
  TOP w0.114: L7.1 154.33,60.42 arc(153.95,60.58) 153.8,60.96 153.8,61.19 arc(153.05,62.98) 151.26,63.73 149.44,63.73 arc(148.77,63.86) 148.19,64.25 arc(147.92,64.43) 147.6,64.49 130.51,64.49 arc(127.53,65.08) 124.99,66.78 124.33,67.44 arc(123.71,67.85) 122.99,68 121.87,68 arc(120.43,68.59) 119.84,70.03 119.84,92.79 arc(118.15,96.86) 114.07,98.55 102.74,98.55 arc(101.06,98.22) 99.63,97.27 99.53,97.16 arc(98.45,96.44) 97.18,96.19 94.49,96.19 arc(92.67,95.44) 91.92,93.62 91.92,87.82 arc(90.97,85.53) 88.68,84.58 64.59,84.58 arc(63.12,83.97) 62.51,82.5 62.51,75.1 arc(62.48,74.97) 62.41,74.85 arc(62.34,74.77) 62.29,74.68 arc(62.27,74.59) 62.26,74.5 62.26,74.45 arc(62.19,74.08) U23.U1
USB0_TXN: length 144
  TOP w0.114: C186.2 155.56,61.45 arc(155.62,61.71) 155.4,61.86 154.81,61.86 arc(154.44,62.01) 154.28,62.39 154.28,62.74 arc(153.81,63.87) 152.68,64.34 149.58,64.34 arc(149.02,64.45) 148.54,64.77 arc(148.17,65.01) 147.74,65.1 131.81,65.1 arc(128.59,65.74) 125.86,67.56 122.5,70.92 arc(121.68,72.15) 121.39,73.61 121.39,92.63 arc(119.47,97.27) 114.83,99.19 102.4,99.19 arc(100.84,98.88) 99.52,97.99 99.18,97.66 arc(98.23,97.02) 97.1,96.8 94.34,96.8 arc(92.2,95.91) 91.31,93.78 91.31,88.27 arc(90.4,86.07) 88.19,85.15 64.34,85.15 arc(62.61,84.44) 61.9,82.71 61.9,77.24 61.9,76.9 arc(61.8,76.38) 61.5,75.94 arc(61.37,75.74) 61.32,75.5 61.32,74.97 arc(61.35,74.81) 61.44,74.68 arc(61.54,74.54) 61.57,74.37 61.57,73.69 arc(61.63,73.39) 61.8,73.14 U23.U2
USB0_TXP: length 143.9
  TOP w0.114: U23.V2 60.93,73.21 arc(60.82,73.37) 60.78,73.56 60.78,74.47 arc(60.8,74.58) 60.84,74.68 arc(60.89,74.75) 60.95,74.82 61.02,74.89 arc(61.08,74.98) 61.09,75.08 61.09,75.5 arc(61.16,75.82) 61.34,76.1 arc(61.59,76.46) 61.67,76.9 61.67,77.34 61.67,77.34 61.67,82.71 arc(62.45,84.6) 64.34,85.38 88.19,85.38 arc(90.24,86.23) 91.08,88.27 91.08,93.78 arc(92.04,96.08) 94.34,97.03 97.1,97.03 arc(98.14,97.23) 99.02,97.82 99.36,98.15 arc(100.75,99.09) 102.4,99.42 114.83,99.42 arc(119.63,97.43) 121.62,92.63 121.62,73.61 arc(121.89,72.24) 122.66,71.08 126.02,67.73 arc(128.67,65.95) 131.81,65.33 147.74,65.33 arc(148.26,65.23) 148.7,64.93 arc(149.11,64.66) 149.58,64.57 152.68,64.57 arc(153.97,64.03) 154.51,62.74 154.51,62.39 arc(154.6,62.18) 154.81,62.09 154.97,62.09 arc(155.26,62.21) 155.38,62.5 C189.2
USB0_VDD3V3: length 3.7
  TOP w0.254: U23.W10 v6(59.98,66.96)
  L5_SIG2 w0.127: 57.81,66.65 57.8,66.65 57.73,66.58 57.42,66.58 57.35,66.65 ; 58.09,66.67 58.13,66.67 58.22,66.58 58.53,66.58 58.62,66.67 58.67,66.67 ; 58.93,66.62 58.98,66.62 59.02,66.58 59.33,66.58 59.37,66.62 59.44,66.62
  BOTTOM w0.152: C499.1 C524.1
  BOTTOM w0.254: v6(59.98,66.96) C524.1
  vias: v5(32.56,75.08)
USB0_VDDA33: length 0.6
  TOP w0.127: U15.N18 v1(152.22,100.08)
USB0DN: length 138.9
  TOP w0.114: U23.W3 v6(59.98,72.56)
  BOTTOM w0.114: L8.2 132.51,64.45 arc(130.7,65.2) 129.95,67.02 129.95,76.97 arc(128.76,79.83) 125.91,81.01 118.9,81.01 arc(113.88,83.09) 111.8,88.11 111.8,91.01 arc(110.06,95.21) 105.87,96.95 93.29,96.95 arc(91.37,96.15) 90.58,94.23 90.58,93.35 arc(90.35,92.19) 89.69,91.21 88.61,90.13 arc(87.93,89.67) 87.12,89.51 84.49,89.51 arc(83.82,89.38) 83.26,89 arc(82.94,88.79) 82.57,88.72 69.8,88.72 arc(69.17,88.46) 68.91,87.83 68.91,86.44 arc(68.59,85.66) 67.82,85.34 64.11,85.34 arc(62.91,84.85) 62.41,83.64 62.41,82.74 arc(62.21,81.74) 61.65,80.9 arc(61.19,80.22) 61.04,79.43 61.04,76.88 arc(60.94,76.37) 60.65,75.95 arc(60.43,75.61) 60.35,75.22 60.35,73.33 arc(60.28,72.96) 60.07,72.65 v6(59.98,72.56)
USB0DP: length 138.8
  TOP w0.114: U23.V3 v6(60.78,72.56)
  BOTTOM w0.114: v6(60.78,72.56) 60.67,72.56 arc(60.5,72.65) 60.48,72.84 60.51,72.94 arc(60.56,73.13) 60.58,73.33 60.58,75.22 arc(60.64,75.53) 60.81,75.79 arc(61.15,76.29) 61.26,76.88 61.26,79.43 arc(61.41,80.14) 61.81,80.74 arc(62.42,81.66) 62.64,82.74 62.64,83.64 arc(63.07,84.68) 64.11,85.12 67.82,85.12 arc(68.75,85.5) 69.14,86.44 69.14,87.83 arc(69.33,88.29) 69.8,88.49 82.57,88.49 arc(83.03,88.58) 83.42,88.84 arc(83.91,89.17) 84.49,89.28 87.12,89.28 arc(88.01,89.46) 88.77,89.97 89.85,91.05 arc(90.56,92.1) 90.81,93.35 90.81,94.23 arc(91.53,95.99) 93.29,96.72 105.87,96.72 arc(109.9,95.05) 111.57,91.01 111.57,88.11 arc(113.72,82.93) 118.9,80.78 125.91,80.78 arc(128.6,79.67) 129.72,76.97 129.72,67.02 arc(130.54,65.04) 132.51,64.22 155.71,64.22 arc(156,64.17) 156.24,64.01 156.53,63.71 arc(156.6,63.67) L8.1
USB0DRVVBUS: length 230.7
  TOP w0.254: U23.AB1 v6(57.58,74.16) ; R533.1 v2(149.97,55.53)
  L8_SIG3 w0.107: v1(106.17,100.46) 106.05,100.58 106.05,102.01 105.82,102.23 104.75,102.23 104.47,101.96 96.65,101.96 96.4,101.7 96.42,101.68 96.42,99.47 96.27,99.32 96.27,99.31 95.91,98.96 95.91,96.73 92.11,92.94 92.11,92.27 92.11,91.7 91.58,91.17 88.74,88.33 88.74,86.96 88.21,86.43 87.05,85.27 77.9,85.27 76.86,84.23 76.1,84.23 64.79,84.23 62.28,81.72 62.28,77.92 59.67,75.31 58.22,75.31 57.58,74.67 v6(57.58,74.16)
  BOTTOM w0.152: v1(106.17,100.46) 105.46,100.46 105,100.91 105,101.73 105.31,102.03 107.65,102.03 113.79,95.89 113.79,87.78 119,82.58 130.02,82.58 131.88,80.72 131.88,77.29 133.88,75.29 166.04,75.29 166.55,74.78 167.11,74.78 175.13,66.75 175.13,40.97 173.79,39.62 172.14,39.62 163.86,47.9 149.94,47.9 146.63,51.21 146.63,54.84 147.33,55.53 v2(149.97,55.53)
USB0VBUS: length 10.7
  TOP w0.254: v1(159.26,55.35) 159.44,55.53 C174.1 158.78,56.31 158.26,56.82 U29.A2 ; J7.1 v1(164.11,57.16)
  L8_SIG3 w0.254: v1(164.11,57.16) 162.17,55.35 v1(159.26,55.35)
USB1_0V85: length 3.7
  TOP w0.254: U23.T9 v6(63.18,67.76) ; U23.R8 v6(63.98,68.56)
  L8_SIG3 w0.381: v6(63.98,68.56) 63.98,68.56 63.65,68.88 ; v6(63.18,67.76) 63,67.76 62.89,67.87
  BOTTOM w0.254: C498.1 v6(63.98,68.56) ; C513.1 v6(63.18,67.76)
  BOTTOM w0.508: v5(72.44,81.84) 72.05,82.23 FB22.1
USB1_ID: length 215.8
  TOP w0.152: J6.4 v3(173.74,40.51) ; U23.W6 v6(59.98,70.16) ; R172.2 44.1,90.23 v1(43.94,90.07)
  L5_SIG2 w0.107: v6(59.98,70.16) 60.41,70.59 60.41,72.85 60.54,72.97 60.67,73.11 60.67,75.42 58.69,77.4 55.8,80.3 55.8,84.16 54.58,85.38 52.45,85.38 50.4,87.43 47.96,87.43 47.11,88.28 45.73,88.28 v1(43.94,90.07)
  L8_SIG3 w0.107: v6(59.98,70.16) 59.98,70.19 60.41,70.62 60.41,71.91 60.41,71.91 60.41,72.71 60.65,72.96 60.65,74.64 63.42,77.41 63.42,81.23 65.28,83.08 75.63,83.08 77.37,83.08 78.41,84.12 87.57,84.12 92.84,89.39 92.84,90.81 93.26,91.23 93.26,92.44 97.66,96.85 101.9,96.85 105.66,100.61 v1(105.66,101.55)
  BOTTOM w0.152: v3(173.74,40.51) 174.55,41.33 174.55,66.82 167.08,74.3 166.52,74.3 165.89,74.93 133.5,74.93 131.39,77.04 131.39,80.54 130.03,81.91 118.85,81.91 113.36,87.4 113.36,95.87 107.68,101.55 v1(105.66,101.55)
USB1_RXN: length 160.2
  TOP w0.114: L3.2 166.94,47.23 arc(166.85,47.46) 166.62,47.55 166.42,47.55 arc(166.35,47.56) 166.29,47.6 arc(166.17,47.68) 166.03,47.71 154.51,47.71 arc(152.59,48.51) 151.79,50.43 151.79,60.02 arc(151.26,61.3) 149.99,61.82 137.53,61.82 arc(136.93,61.94) 136.42,62.28 arc(136.11,62.49) 135.75,62.56 125.44,62.56 arc(124.51,62.75) 123.72,63.27 arc(123.13,63.67) 122.44,63.8 120.97,63.8 arc(119.81,64.04) 118.82,64.69 arc(117.5,65.58) 115.94,65.89 111.96,65.89 arc(109.45,66.93) 108.41,69.44 108.41,91.19 arc(106.87,94.89) 103.17,96.42 102.47,96.42 arc(101.55,96.23) 100.77,95.71 100.69,95.63 arc(99.19,94.63) 97.44,94.28 94.61,94.28 arc(94.04,94.05) 93.8,93.47 93.8,87.32 arc(92.46,84.09) 89.23,82.75 79.93,82.75 arc(78.85,82.54) 77.94,81.93 77.94,81.93 arc(76.8,81.17) 75.46,80.9 65.28,80.9 arc(64.61,80.62) 64.34,79.96 64.34,76.34 arc(64.37,76.16) 64.47,76.01 arc(64.75,75.62) 64.89,75.17 64.89,74.27 arc(64.93,74.07) 65.04,73.89 U23.N1
USB1_RXN_R: length 6.5
  TOP w0.114: J6.9 arc(174.84,47.37) 174.57,47.42 173.99,47.42 172.3,47.42 arc(172.13,47.39) U24.11 arc(171.73,47.39) 171.46,47.42 arc(171.18,47.39) U24.4 arc(170.77,47.39) 170.6,47.42 169.48,47.42 arc(169.11,47.35) L3.3
USB1_RXP: length 160.2
  TOP w0.114: L3.1 154.51,47.94 arc(152.75,48.67) 152.02,50.43 152.02,60.02 arc(151.42,61.46) 149.99,62.05 137.53,62.05 arc(137.02,62.15) 136.59,62.44 arc(136.2,62.7) 135.75,62.79 125.44,62.79 arc(124.6,62.96) 123.89,63.43 arc(123.22,63.88) 122.44,64.03 120.97,64.03 arc(119.89,64.25) 118.98,64.86 arc(117.59,65.79) 115.94,66.12 111.96,66.12 arc(109.61,67.09) 108.64,69.44 108.64,91.19 arc(107.04,95.05) 103.17,96.65 102.47,96.65 arc(101.46,96.45) 100.6,95.87 100.52,95.79 arc(99.11,94.85) 97.44,94.51 94.61,94.51 arc(93.88,94.21) 93.57,93.47 93.57,87.32 arc(92.3,84.25) 89.23,82.98 79.93,82.98 arc(78.77,82.75) 77.78,82.09 arc(76.71,81.38) 75.46,81.13 65.28,81.13 arc(64.45,80.79) 64.11,79.96 64.11,76.33 arc(64.16,76.07) 64.31,75.84 arc(64.54,75.53) 64.66,75.15 64.66,74.44 arc(64.58,74.07) U23.P1
USB1_RXP_R: length 6.5
  TOP w0.114: J6.10 arc(174.84,47.71) 174.57,47.65 172.3,47.65 arc(172.13,47.69) U24.12 arc(171.73,47.69) 171.46,47.65 arc(171.18,47.69) U24.3 arc(170.77,47.69) 170.6,47.65 169.48,47.65 arc(169.11,47.73) L3.4
USB1_TXN: length 161.3
  TOP w0.114: C129.2 164.85,49.8 arc(164.76,49.58) 164.54,49.49 155.96,49.49 arc(155.39,49.54) 154.85,49.7 arc(153.48,50.8) 152.96,52.48 152.96,59.97 arc(152.11,62.02) 150.06,62.87 137.82,62.87 arc(137.44,62.94) 137.12,63.15 arc(136.62,63.49) 136.04,63.6 127.08,63.6 arc(125.47,63.92) 124.11,64.83 123.84,65.1 arc(123.11,65.59) 122.25,65.76 121.14,65.76 arc(120.33,65.92) 119.64,66.38 arc(118.53,67.12) 117.21,67.39 112.47,67.39 arc(110.71,68.12) 109.98,69.88 109.98,92.3 arc(108.4,96.13) 104.57,97.71 102.72,97.71 arc(101.34,97.44) 100.17,96.66 100.08,96.57 arc(98.73,95.67) 97.14,95.35 94.59,95.35 arc(93.31,94.82) 92.77,93.54 92.77,87.54 arc(91.67,84.88) 89.02,83.78 64.74,83.78 arc(63.73,83.36) 63.31,82.35 63.31,75.58 arc(63.33,75.46) 63.4,75.36 arc(63.45,75.28) 63.47,75.18 63.47,75.07 arc(63.45,74.94) 63.37,74.83 63.3,74.75 arc(63.27,74.72) 63.24,74.68 arc(63.2,74.58) 63.18,74.47 63.18,73.56 arc(63.22,73.37) 63.33,73.21 U23.R2
USB1_TXN_R: length 13.1
  TOP w0.114: J6.6 175.97,45.26 arc(176.24,45.38) 176.35,45.64 176.35,48.51 arc(176.19,48.91) 175.79,49.07 173.21,49.07 arc(172.87,49.01) 172.59,48.82 172.52,48.74 arc(172.42,48.68) 172.3,48.65 arc(172.13,48.69) U24.14 arc(171.73,48.69) 171.46,48.65 arc(171.18,48.69) U24.1 arc(170.77,48.69) 170.6,48.65 170.28,48.65 arc(170.16,48.71) 170.1,48.83 170.1,49 arc(169.96,49.34) 169.62,49.49 169.46,49.49 arc(169.08,49.56) L4.4
USB1_TXP: length 161.4
  TOP w0.114: C126.2 165.07,48.9 arc(165.13,49.04) 165.07,49.17 arc(164.98,49.24) 164.87,49.26 155.96,49.26 arc(155.35,49.31) 154.77,49.48 arc(153.29,50.67) 152.73,52.48 152.73,59.97 arc(151.95,61.86) 150.06,62.64 137.82,62.64 arc(137.35,62.73) 136.96,62.99 arc(136.53,63.27) 136.04,63.37 127.08,63.37 arc(125.39,63.71) 123.95,64.67 123.68,64.94 arc(123.02,65.38) 122.25,65.53 121.14,65.53 arc(120.24,65.71) 119.48,66.22 arc(118.44,66.91) 117.21,67.16 112.47,67.16 arc(110.55,67.95) 109.75,69.88 109.75,92.3 arc(108.24,95.97) 104.57,97.49 102.72,97.49 arc(101.43,97.23) 100.33,96.49 100.24,96.41 arc(98.82,95.46) 97.14,95.12 94.59,95.12 arc(93.47,94.66) 93,93.54 93,87.54 arc(91.83,84.72) 89.02,83.55 64.74,83.55 arc(63.89,83.2) 63.54,82.35 63.54,75.58 arc(63.54,75.55) 63.56,75.52 arc(63.67,75.37) 63.7,75.18 63.7,75.16 arc(63.74,74.99) 63.83,74.86 63.84,74.84 arc(63.9,74.76) 63.95,74.68 arc(63.96,74.61) 63.97,74.54 63.97,73.69 arc(64.03,73.39) 64.2,73.14 U23.P2
USB1_TXP_R: length 12.7
  TOP w0.114: J6.7 175.27,45.91 arc(175.52,45.86) 175.74,45.72 arc(175.86,45.67) 175.98,45.72 arc(176.09,45.88) 176.12,46.06 176.12,46.32 176,46.44 176,46.77 176.12,46.9 176.12,47.35 176,47.47 176,47.8 176.12,47.93 176.12,48.51 arc(176.03,48.75) 175.79,48.84 175.55,48.84 175.4,48.69 175.09,48.69 174.94,48.84 174.7,48.84 174.52,48.67 174.24,48.67 174.07,48.84 173.21,48.84 arc(172.96,48.8) 172.75,48.66 172.68,48.58 arc(172.51,48.46) 172.3,48.42 172.3,48.42 arc(172.13,48.39) U24.13 arc(171.73,48.39) 171.46,48.42 arc(171.18,48.39) U24.2 arc(170.77,48.39) 170.6,48.42 170.2,48.42 arc(170.12,48.44) 170.05,48.48 169.99,48.54 arc(169.91,48.68) 169.88,48.83 169.88,49 arc(169.8,49.18) 169.62,49.26 169.46,49.26 arc(169.08,49.18) L4.3
USB1_VDD3V3: length 2.7
  TOP w0.254: U23.R10 v6(63.98,66.96)
  BOTTOM w0.254: C512.1 v6(63.98,66.96) C523.1
  BOTTOM w0.508: FB27.1 31.88,64.52 32,64.39 v5(32,64.14)
USB1DN: length 160.5
  TOP w0.114: v1(164.18,45.28) 164.22,45.32 arc(164.32,45.41) 164.43,45.47 arc(164.57,45.51) 164.71,45.52 166.28,45.52 arc(166.65,45.45) L5.2 ; U23.P4 v6(64.78,71.76)
  BOTTOM w0.114: v1(164.18,45.28) 164.13,45.32 arc(163.91,45.47) 163.65,45.52 153.15,45.52 arc(150.7,46.01) 148.62,47.4 145.91,50.1 arc(144.92,51.59) 144.58,53.33 144.58,59.92 arc(143.82,61.75) 141.99,62.51 132.56,62.51 arc(129.69,63.7) 128.5,66.57 128.5,77.39 arc(127.74,79.22) 125.91,79.98 117.45,79.98 arc(112.73,81.94) 110.77,86.66 110.77,90.33 arc(109.15,94.26) 105.22,95.89 93.74,95.89 arc(92.27,95.28) 91.67,93.81 91.67,93.27 arc(91.66,93.08) 91.64,92.89 91.64,92.43 arc(91.51,91.75) 91.13,91.18 89.48,89.53 88.76,88.81 arc(86.47,87.28) 83.77,86.74 77.88,86.74 arc(77.06,86.9) 76.37,87.37 arc(76.01,87.6) 75.59,87.69 73.04,87.69 arc(71.63,87.11) 71.05,85.7 71.05,85.22 arc(70.53,83.97) 69.29,83.46 64.84,83.46 arc(64.52,83.32) 64.38,83 64.38,74.62 arc(64.29,74.18) 64.04,73.8 63.97,73.73 arc(63.86,73.56) 63.82,73.36 arc(63.86,73.15) 63.98,72.98 arc(64.04,72.94) 64.11,72.92 64.19,72.92 arc(64.26,72.91) 64.32,72.87 arc(64.37,72.8) 64.38,72.71 arc(64.48,72.2) v6(64.78,71.76)
USB1DN_R: length 12.5
  TOP w0.114: J6.2 arc(174.84,39.37) 174.57,39.42 173.84,39.42 arc(173.14,39.71) 172.85,40.41 172.85,45.38 arc(172.69,45.77) 172.3,45.92 arc(172.13,45.89) U24.8 arc(171.73,45.89) 171.46,45.92 arc(171.18,45.89) U24.7 arc(170.67,45.89) 170.39,45.92 arc(170.23,45.89) 170.09,45.8 170,45.71 arc(169.79,45.57) 169.56,45.52 arc(169.16,45.45) L5.3
USB1DP: length 160.6
  TOP w0.114: U23.R4 v6(63.98,71.76) ; v1(164.18,46) 164.22,45.95 arc(164.44,45.8) 164.71,45.75 166.28,45.75 arc(166.65,45.83) L5.1
  BOTTOM w0.114: v1(164.18,46) 164.13,45.95 arc(163.91,45.8) 163.65,45.75 153.15,45.75 arc(150.78,46.22) 148.78,47.56 146.08,50.27 arc(145.14,51.67) 144.81,53.33 144.81,59.92 arc(143.98,61.91) 141.99,62.74 132.56,62.74 arc(129.85,63.86) 128.73,66.57 128.73,77.39 arc(127.9,79.39) 125.91,80.21 117.45,80.21 arc(112.89,82.1) 111,86.66 111,90.33 arc(109.31,94.42) 105.22,96.11 93.74,96.11 arc(92.11,95.44) 91.44,93.81 91.44,93.27 arc(91.43,93.09) 91.42,92.92 91.42,92.91 91.42,92.43 arc(91.3,91.84) 90.96,91.34 89.32,89.7 88.59,88.97 arc(86.38,87.49) 83.77,86.97 77.88,86.97 arc(77.15,87.11) 76.53,87.53 arc(76.1,87.82) 75.59,87.92 73.04,87.92 arc(71.47,87.27) 70.82,85.7 70.82,85.22 arc(70.37,84.13) 69.29,83.69 64.84,83.69 arc(64.35,83.49) 64.15,83 64.15,74.62 arc(64.08,74.27) 63.88,73.97 63.81,73.89 arc(63.65,73.65) 63.59,73.36 63.59,73.32 arc(63.59,73.27) 63.6,73.23 63.65,72.9 arc(63.65,72.82) 63.6,72.75 63.6,72.54 arc(63.68,72.17) 63.89,71.85 v6(63.98,71.76)
USB1DP_R: length 12.5
  TOP w0.114: J6.3 arc(174.84,39.71) 174.57,39.65 173.84,39.65 arc(173.3,39.88) 173.08,40.41 173.08,45.38 arc(172.85,45.93) 172.3,46.15 arc(172.13,46.19) U24.9 arc(171.73,46.19) 171.46,46.15 arc(171.18,46.19) U24.6 arc(170.67,46.19) 170.39,46.15 arc(170.14,46.1) 169.93,45.96 169.88,45.92 169.83,45.87 arc(169.71,45.78) 169.56,45.75 arc(169.16,45.83) L5.4
USB1DRVVBUS: length 202
  TOP w0.152: U23.AC1 v6(56.78,74.16)
  TOP w0.254: R223.1 v2(159.96,38.49)
  L8_SIG3 w0.107: v6(56.78,74.16) 56.78,75.1 57.48,75.81 59.52,75.81 61.82,78.11 61.82,81.91 64.6,84.68 76.29,84.68 76.67,84.68 77.71,85.72 86.86,85.72 87.33,86.2 88.28,87.15 88.28,88.52 91.66,91.89 91.66,93.13 92.06,93.53 95.45,96.92 95.45,99.8 95.25,100 95.25,101.57 96.42,102.74 98.34,102.74 98.42,102.67 99.2,102.67 99.27,102.74 105.54,102.74 v1(105.66,102.62)
  BOTTOM w0.203: v2(159.96,38.49) 173.62,38.49 175.69,40.56 175.69,66.83 167.38,75.14 167.38,75.45 167.13,75.7 150.43,75.7 150.37,75.64 149.86,75.64 149.8,75.7 137.66,75.7 130.05,83.31 119.2,83.31 114.22,88.29 114.22,96.01 107.62,102.62 v1(105.66,102.62)
USB1VBUS: length 2.3
  TOP w0.254: C150.1 154.31,34 U28.A2
USB_CLKN: length 20.2
  TOP w0.102: U18.21 67.67,90.71 67.55,90.59 67.55,90.49 68.68,89.36 69.29,89.36 70.26,88.39 70.26,87.69 v1(70.52,87.43)
  BOTTOM w0.102: v1(70.52,87.43) 70.26,87.16 70.26,85.59 68.91,84.25 64.31,84.25 63.59,83.53 63.59,80.54 62.78,79.73 62.78,79.35 62.94,79.19 C462.1
USB_CLKN_R: length 8
  TOP w0.102: U23.T4 v6(63.18,71.76)
  BOTTOM w0.102: C462.2 62.91,78.29 62.78,78.16 62.78,75.34 62.47,75.03 62.47,73.79 62.74,73.51 62.74,72.19 63.17,71.76 v6(63.18,71.76)
USB_CLKP: length 20.2
  TOP w0.102: v1(69.74,87.43) 70,87.69 70,88.29 69.19,89.1 68.57,89.1 67.29,90.38 67.29,90.59 67.17,90.71 U18.20
  BOTTOM w0.102: v1(69.74,87.43) 70,87.16 70,85.7 68.81,84.51 64.21,84.51 63.33,83.63 63.33,80.65 62.52,79.84 62.52,79.38 62.34,79.19 C463.1
USB_CLKP_R: length 8
  TOP w0.102: U23.U4 v6(62.38,71.76)
  BOTTOM w0.102: C463.2 62.43,78.29 62.52,78.2 62.52,75.44 62.22,75.14 62.22,73.75 62.01,73.54 62.01,72.13 v6(62.38,71.76)
USB_RXN_R: length 30.1
  TOP w0.114: J7.5 166.23,65.91 arc(166.72,65.81) 167.12,65.54 167.89,64.77 167.89,64.77 168.06,64.77 arc(168.35,64.71) 168.59,64.55 arc(169.11,63.77) 169.29,62.86 169.29,56.31 arc(169.03,54.98) 168.27,53.85 167.9,53.48 arc(167.55,53.24) 167.13,53.16 164.95,53.16 arc(164.2,53.31) 163.57,53.74 arc(162.97,54.63) 162.76,55.68 162.76,60.1 arc(162.76,60.17) 162.74,60.24 162.68,60.3 arc(162.62,60.34) 162.54,60.36 arc(162.36,60.32) U30.8 arc(161.96,60.32) 161.69,60.36 arc(161.42,60.32) U30.7 arc(161.01,60.32) 160.83,60.36 160.66,60.36 arc(160.54,60.31) 160.47,60.2 arc(160.35,59.99) 160.12,59.91 arc(159.74,59.83) L7.3
USB_RXP_R: length 29.4
  TOP w0.114: J7.6 166.24,63.41 arc(166.72,63.51) 167.13,63.78 167.86,64.51 arc(167.9,64.53) 167.94,64.54 168.06,64.54 arc(168.26,64.5) 168.43,64.39 arc(168.9,63.69) 169.06,62.86 169.06,56.31 arc(168.81,55.07) 168.11,54.01 167.74,53.64 arc(167.46,53.46) 167.13,53.39 164.95,53.39 arc(164.29,53.52) 163.73,53.9 arc(163.18,54.71) 162.99,55.68 162.99,60.16 arc(162.99,60.21) 162.98,60.26 162.96,60.31 arc(162.95,60.34) 162.94,60.37 162.84,60.46 arc(162.7,60.55) 162.54,60.59 arc(162.36,60.62) U30.9 arc(161.96,60.62) 161.69,60.59 arc(161.42,60.62) U30.6 arc(161.01,60.62) 160.83,60.59 160.65,60.59 arc(160.5,60.56) 160.36,60.47 160.28,60.39 arc(160.26,60.35) 160.25,60.3 160.25,60.24 arc(160.2,60.17) 160.12,60.14 arc(159.74,60.21) L7.4
USB_SHIELD: length 36.2
  TOP w0.254: v1(162.79,61.22) U30.10 U30.5 ; v1(172.92,46.79) U24.10 U24.5
  TOP w0.508: 171.16,52.67 J7.SH1 ; J7.SH1 171.16,55.55 ; J7.SH1 173.04,54.11 ; J7.SH2 173.04,67.71 ; J7.SH2 171.16,66.27 ; J7.SH2 169.28,67.71
  L3_SIG1 w0.635: v1(162.79,61.22) 162.92,55.4 164.2,54.11 J7.SH1 172.92,52.34 v1(172.92,46.79)
USB_VBUS: length 21.6
  TOP w0.254: v3(167.82,142.27) 167.82,142.04 167.33,141.55 R613.1
  BOTTOM w0.508: 166.9,133.1 166.37,133.1 164.54,134.92 164.54,138.86 v3(164.08,139.32) 162.81,139.32 161.47,140.67 161.47,141.87 162.02,142.42 162.2,142.6 163.68,142.6 164.8,143.71 167.32,143.71 167.82,143.22 v3(167.82,142.27)
USB_VBUS_EN: length 126.9
  TOP w0.152: v2(119.68,123.67) 119.68,122.45 119.44,122.21 R57.2 ; U28.B2 v2(153.93,32.49) ; U29.B2 156.84,56.82 v1(156.84,56.26) 157.4,55.7 R664.2
  L3_SIG1 w0.102: v2(119.68,123.67) 121.39,121.97 121.39,121.23 121.46,121.16 121.46,108.18 121.77,107.87 121.77,101.45 122.78,100.43 122.78,96.75 124.36,95.17 137.54,95.17 139.4,97.03 141.27,97.03 142.77,95.53 142.77,87.5 141.55,86.28 141.55,70.74 156.03,56.26 v1(156.84,56.26) 156.84,54.66 153.7,51.51 153.7,36.55 153.93,36.32 v2(153.93,32.49)
USB_VBUS_R: length 9.4
  L3_SIG1 w0.381: v3(169.19,131.11) 169.19,134.02 166.76,136.45 v3(166.65,136.45)
  BOTTOM w0.254: D13.6 166.66,136.44 v3(166.65,136.45)
  BOTTOM w0.381: 170.52,134.19 J1.1 171.8,134.19
  vias: v3(170.41,131.11)
USB_VIO: length 1.3
  TOP w0.127: 165.35,136.65 165.22,136.51 U2.5
  TOP w0.381: R6.1 v3(162.56,141.71)
  vias: v3(167.06,139.34) v3(167.08,138.38)
USBDN_R: length 19.2
  TOP w0.114: J7.2 166.19,59.66 arc(166.42,59.71) 166.62,59.84 167.56,60.79 167.56,60.78 167.96,60.78 arc(168.28,60.72) v1(168.55,60.54) ; v1(159.44,64.45) arc(159.52,64.25) 159.72,64.17 arc(160.08,64.02) 160.22,63.67 160.22,63.39 arc(160.31,63.18) 160.53,63.09 160.83,63.09 arc(161.01,63.12) U30.1 arc(161.42,63.12) 161.69,63.09 arc(161.96,63.12) U30.14 arc(162.36,63.12) 162.54,63.09 162.87,63.09 arc(163.06,63.17) 163.14,63.36 163.14,64.06 arc(163.06,64.46) v1(162.84,64.8)
  BOTTOM w0.114: L8.3 158.68,64.3 arc(158.82,64.2) 158.99,64.17 159.15,64.17 arc(159.35,64.25) v1(159.44,64.45) ; v1(168.55,60.54) arc(168.28,60.72) 167.96,60.78 165.64,60.78 arc(164.73,60.96) 163.95,61.48 163.68,61.76 arc(163.23,62.43) 163.07,63.22 163.07,64.13 arc(163.07,64.14) 163.07,64.14 163.07,64.22 arc(163.01,64.53) v1(162.84,64.8)
USBDP_R: length 19.1
  TOP w0.114: J7.3 166.18,62.16 arc(166.4,62.12) 166.58,61.99 167.53,61.04 arc(167.57,61.02) 167.61,61.01 167.96,61.01 arc(168.28,61.07) v1(168.55,61.26) ; v1(159.44,63.65) arc(159.52,63.86) 159.72,63.94 159.72,63.94 arc(159.91,63.86) 159.99,63.67 159.99,63.39 arc(160.15,63.01) 160.53,62.86 160.83,62.86 arc(161.01,62.82) U30.2 arc(161.42,62.82) 161.69,62.86 arc(161.96,62.82) U30.13 arc(162.36,62.82) 162.54,62.86 162.87,62.86 arc(163.22,63.01) 163.37,63.36 163.37,64.28 arc(163.43,64.54) v1(163.58,64.77)
  BOTTOM w0.114: L8.4 158.68,63.81 arc(158.82,63.91) 158.99,63.94 159.15,63.94 arc(159.35,63.86) v1(159.44,63.65) ; v1(163.58,64.77) arc(163.37,64.46) 163.3,64.1 163.3,63.22 arc(163.44,62.52) 163.84,61.92 164.11,61.65 arc(164.81,61.18) 165.64,61.01 167.96,61.01 arc(168.28,61.07) v1(168.55,61.26)
USRSTN: length 3.5
  TOP w0.152: R117.1 118.83,103.45 117.73,104.55 U9.31
UTCA_SGMII4_RX_DN: length 100.5
  TOP w0.102: C143.2 42.35,54.66 42.25,54.56 41.94,54.56 41.81,54.69 41.58,54.69 41.45,54.56 41.23,54.56 41.1,54.69 40.87,54.69 40.74,54.56 40.51,54.56 40.31,54.76 40.03,54.76 v1(39.83,54.96)
  L3_SIG1 w0.102: J2.B2 9.8,114.1 9.73,114.03 9.73,113.49 9.88,113.33 25.94,113.33 26.86,112.41 26.86,85.74 24.78,83.65 22.05,83.65 20.54,82.14 20.54,71.26 23.72,68.07 23.72,59.21 30.07,52.86 37.05,52.86 38.97,54.78 39.65,54.78 v1(39.83,54.96)
UTCA_SGMII4_RX_DN_R: length 7.1
  TOP w0.102: U23.AN23 48.9,55.89 45.43,55.89 44.22,54.67 43.31,54.67 43.25,54.73 C143.1
UTCA_SGMII4_RX_DP: length 100.5
  TOP w0.102: C145.2 42.35,54.22 42.27,54.31 40.41,54.31 40.21,54.51 40.03,54.51 v1(39.83,54.3)
  L3_SIG1 w0.102: J2.A2 9.37,114.1 9.44,114.03 9.44,113.37 9.76,113.04 25.82,113.04 26.57,112.29 26.57,85.86 24.66,83.95 21.93,83.95 20.24,82.26 20.24,71.14 23.43,67.95 23.43,59.09 29.95,52.57 37.17,52.57 39.09,54.49 39.65,54.49 v1(39.83,54.3)
UTCA_SGMII4_RX_DP_R: length 7.1
  TOP w0.102: U23.AN24 48.9,55.63 45.54,55.63 44.33,54.42 43.36,54.42 43.25,54.31 C145.1
UTCA_SGMII4_TX_DN: length 108.9
  TOP w0.102: U23.AL24 v6(50.38,54.96)
  L3_SIG1 w0.102: J2.B1 9.72,111.6 9.61,111.71 9.61,112 9.93,112.32 25.19,112.32 25.65,111.85 25.65,86.13 24.4,84.87 21.63,84.87 19.42,82.66 19.42,69.86 20.87,68.41 20.87,60.15 29.19,51.83 40.41,51.83 43.66,55.08 49.88,55.08 50.01,55.21 50.25,55.21 50.38,55.09 v6(50.38,54.96)
UTCA_SGMII4_TX_DP: length 108.9
  TOP w0.102: U23.AL23 v6(50.38,55.76)
  L3_SIG1 w0.102: J2.A1 9.32,111.92 9.32,112.12 9.81,112.61 25.31,112.61 25.95,111.98 25.95,86.01 24.52,84.58 21.75,84.58 19.71,82.54 19.71,69.98 21.16,68.53 21.16,60.27 29.31,52.12 40.29,52.12 43.54,55.37 49.76,55.37 49.89,55.51 50.12,55.51 v6(50.38,55.76)
UTCA_SGMII5_RX_DN: length 100.6
  TOP w0.102: C136.2 40.32,56.79 40.24,56.71 37.58,56.71 37.21,56.34 37.21,55.78 37.13,55.7 36.7,55.7 36.63,55.7 v1(36.42,55.9)
  L3_SIG1 w0.102: v1(36.42,55.9) 36.61,55.72 37.1,55.72 37.39,55.43 37.39,54.76 36.77,54.14 34.69,54.14 34.26,54.57 34.26,55.47 33.93,55.8 31.49,55.8 25.64,61.65 25.64,68.23 24.83,69.04 24.83,81.65 28.17,84.99 28.17,117.25 25.36,120.05 10.06,120.05 9.75,119.74 9.75,119.55 J2.B4
UTCA_SGMII5_RX_DN_R: length 9.7
  TOP w0.102: U23.AM22 49.59,57.35 48.46,57.35 48.19,57.07 43.45,57.07 43.08,56.71 41.33,56.71 41.22,56.81 C136.1
UTCA_SGMII5_RX_DP: length 100.6
  TOP w0.102: v1(36.42,55.24) 36.63,55.45 37.23,55.45 37.47,55.68 37.47,56.24 37.68,56.45 37.91,56.45 38.02,56.34 38.25,56.34 38.37,56.45 38.6,56.45 38.71,56.34 38.94,56.34 39.05,56.45 39.28,56.45 39.4,56.34 39.62,56.34 39.74,56.45 40.25,56.45 40.32,56.38 C141.2
  L3_SIG1 w0.102: v1(36.42,55.24) 36.61,55.43 36.98,55.43 37.1,55.31 37.1,54.88 36.65,54.43 36.13,54.43 36.03,54.53 35.8,54.53 35.7,54.43 35.47,54.43 35.37,54.53 35.14,54.53 35.04,54.43 34.81,54.43 34.56,54.69 34.56,55.59 34.06,56.1 31.61,56.1 25.93,61.77 25.93,68.35 25.12,69.16 25.12,81.53 28.46,84.87 28.46,117.37 25.48,120.35 9.94,120.35 9.45,119.86 9.45,119.55 J2.A4
UTCA_SGMII5_RX_DP_R: length 9.7
  TOP w0.102: U23.AM23 49.59,56.55 48.41,56.55 48.14,56.82 43.55,56.82 43.18,56.45 41.3,56.45 41.22,56.37 C141.1
UTCA_SGMII5_TX_DN: length 112.9
  TOP w0.102: U23.AK23 v6(51.18,55.76)
  L3_SIG1 w0.102: v6(51.18,55.76) 51.18,56.04 50.96,56.26 50.59,56.26 50.5,56.16 49.96,56.16 49.87,56.25 39.37,56.25 38.76,55.64 38.76,55.15 36.99,53.38 31.1,53.38 29.25,55.23 29.25,56.7 24.68,61.27 24.68,67.7 21.2,71.18 21.2,81.81 22.29,82.9 24.85,82.9 27.36,85.41 27.36,116.48 26.55,117.28 9.86,117.28 9.65,117.08 9.65,116.72 9.77,116.6 J2.B3
UTCA_SGMII5_TX_DP: length 112.9
  TOP w0.102: U23.AK22 v6(51.18,56.56)
  L3_SIG1 w0.102: J2.A3 9,116.61 9.36,116.97 9.36,117.2 9.74,117.57 26.68,117.57 27.65,116.6 27.65,85.28 24.97,82.61 22.41,82.61 21.49,81.69 21.49,71.3 24.97,67.82 24.97,61.39 29.54,56.82 29.54,55.35 31.22,53.67 36.87,53.67 38.47,55.27 38.47,55.76 39.25,56.54 49.84,56.54 50.22,56.93 50.81,56.93 v6(51.18,56.56)
UTCA_SGMII6_RX_DN: length 99
  TOP w0.102: v1(36.8,58.95) 37.01,58.75 37.8,58.75 38.33,58.22 38.64,58.22 38.77,58.34 39,58.34 39.12,58.22 39.35,58.22 39.48,58.34 39.71,58.34 39.84,58.22 40.06,58.22 40.19,58.34 40.42,58.34 40.55,58.22 40.78,58.22 40.9,58.34 41.13,58.34 41.26,58.22 41.49,58.22 42.01,58.74 42.29,58.74 42.35,58.8 C133.2
  L3_SIG1 w0.102: v1(36.8,58.95) 36.65,58.8 35.57,58.8 35.03,59.33 32.13,59.33 28.85,62.61 28.85,73.89 27.37,75.37 27.37,81.62 30.1,84.35 30.1,120.86 27.54,123.42 9.94,123.42 9.7,123.65 9.7,123.96 9.84,124.1 J2.B6
UTCA_SGMII6_RX_DN_R: length 6.7
  TOP w0.102: C133.1 43.25,58.85 43.36,58.74 44.3,58.74 44.75,58.29 48.9,58.29 U23.AN20
UTCA_SGMII6_RX_DP: length 99
  TOP w0.102: v1(36.8,58.29) 37.01,58.49 37.69,58.49 38.22,57.96 41.59,57.96 42.11,58.48 42.29,58.48 42.35,58.43 C135.2
  L3_SIG1 w0.102: J2.A6 9.27,124.1 9.41,123.96 9.41,123.53 9.82,123.12 27.42,123.12 29.81,120.74 29.81,84.47 27.08,81.74 27.08,75.25 28.56,73.77 28.56,62.49 32.01,59.04 34.91,59.04 35.45,58.51 36.59,58.51 v1(36.8,58.29)
UTCA_SGMII6_RX_DP_R: length 6.7
  TOP w0.102: U23.AN21 48.9,58.03 44.65,58.03 44.2,58.48 43.33,58.48 43.25,58.4 C135.1
UTCA_SGMII6_TX_DN: length 108.6
  TOP w0.102: U23.AL21 v6(50.38,57.36)
  L3_SIG1 w0.102: v6(50.38,57.36) 50.24,57.5 49.79,57.5 49.67,57.38 49.44,57.38 49.32,57.5 49.09,57.5 48.97,57.38 48.74,57.38 48.62,57.5 48.39,57.5 48.27,57.38 48.04,57.38 47.92,57.5 47.69,57.5 47.57,57.38 47.34,57.38 47.22,57.5 46.99,57.5 46.87,57.38 46.64,57.38 46.52,57.5 46.29,57.5 46.17,57.38 45.94,57.38 45.82,57.5 45.59,57.5 45.47,57.38 45.25,57.38 45.12,57.5 44.9,57.5 44.39,57 39.17,57 38.91,56.74 36.42,56.74 35.97,56.29 34.75,56.29 34.18,56.85 34.18,57.97 33.9,58.25 31.67,58.25 27.76,62.16 27.76,72.81 25.64,74.94 25.64,81.38 28.94,84.68 28.94,119.85 26.52,122.28 9.86,122.28 9.78,122.2 9.78,121.77 9.95,121.6 J2.B5
UTCA_SGMII6_TX_DP: length 108.5
  TOP w0.102: U23.AL20 v6(50.38,58.16)
  L3_SIG1 w0.102: J2.A5 9.34,121.6 9.49,121.75 9.49,122.32 9.74,122.57 26.64,122.57 29.24,119.97 29.24,84.56 25.93,81.25 25.93,75.06 28.05,72.94 28.05,62.28 31.79,58.55 34.02,58.55 34.47,58.09 34.47,56.98 34.87,56.58 35.85,56.58 36.3,57.04 38.79,57.04 39.05,57.29 44.27,57.29 44.77,57.79 50.01,57.79 v6(50.38,58.16)
UTCA_SGMII7_RX_DN: length 100
  TOP w0.102: v1(37.34,61.44) 37.55,61.24 37.77,61.24 37.88,61.34 38.11,61.34 38.21,61.24 38.44,61.24 38.54,61.34 38.77,61.34 38.87,61.24 39.12,61.24 39.62,60.73 40.16,60.73 40.32,60.89 C127.2
  L3_SIG1 w0.102: J2.B8 9.81,129.1 9.7,129.21 9.7,129.91 9.93,130.14 24.77,130.14 31.46,123.45 31.46,82.6 29.72,80.86 29.72,76.04 31.18,74.58 31.18,70.01 31.79,69.4 31.79,68.67 31.67,68.55 31.67,68.32 31.79,68.21 31.79,67.98 31.67,67.87 31.67,67.64 31.79,67.52 31.79,67.29 31.67,67.18 31.67,66.95 31.79,66.84 31.79,66.61 31.67,66.49 31.67,66.27 31.79,66.15 31.79,65.92 31.67,65.81 31.67,65.58 31.79,65.46 31.79,65.21 32.56,64.44 32.56,63.9 33.37,63.09 33.63,63.09 33.96,62.77 34.19,62.77 34.32,62.64 34.55,62.64 34.68,62.77 34.91,62.77 35.04,62.64 35.26,62.64 35.4,62.77 35.62,62.77 35.75,62.64 35.98,62.64 36.11,62.77 36.34,62.77 36.47,62.64 36.7,62.64 36.83,62.77 37.06,62.77 37.19,62.64 37.42,62.64 37.55,62.77 37.74,62.77 37.9,62.61 37.9,61.42 37.75,61.27 37.52,61.27 v1(37.34,61.44)
UTCA_SGMII7_RX_DN_R: length 10.1
  TOP w0.102: U23.AM19 49.56,59.77 48.5,59.77 48.2,59.47 44.61,59.47 43.31,60.77 41.33,60.77 41.22,60.88 C127.1
UTCA_SGMII7_RX_DP: length 100.1
  TOP w0.102: v1(37.34,60.78) 37.55,60.98 39.01,60.98 39.52,60.48 40.22,60.48 40.32,60.38 C132.2
  L3_SIG1 w0.102: J2.A8 9.13,129.1 9.41,129.38 9.41,130.03 9.8,130.43 24.89,130.43 31.75,123.57 31.75,82.72 31.75,82.48 30.02,80.75 30.02,80.75 30.01,80.74 30.01,76.16 31.47,74.7 31.47,70.13 32.08,69.52 32.08,65.34 32.85,64.56 32.85,64.02 33.49,63.39 33.75,63.39 34.08,63.06 34.08,63.06 37.87,63.06 38.19,62.73 38.19,61.29 37.87,60.97 37.54,60.97 v1(37.34,60.78)
UTCA_SGMII7_RX_DP_R: length 10.1
  TOP w0.102: U23.AM20 49.59,58.95 48.49,58.95 48.22,59.22 44.5,59.22 43.21,60.52 41.35,60.52 41.22,60.38 C132.1
UTCA_SGMII7_TX_DN: length 112.2
  TOP w0.102: U23.AK20 v6(51.18,58.16)
  L3_SIG1 w0.102: v6(51.18,58.16) 51.18,58.32 50.9,58.59 49.06,58.59 48.94,58.47 48.71,58.47 48.59,58.59 48.36,58.59 48.24,58.47 48.01,58.47 47.89,58.59 47.66,58.59 47.54,58.47 47.31,58.47 47.19,58.59 46.96,58.59 46.84,58.47 46.61,58.47 46.49,58.59 44.84,58.59 44.04,57.78 37.85,57.78 37.44,58.19 37.44,59.39 36.93,59.9 32.23,59.9 29.27,62.85 29.27,74.04 27.77,75.54 27.77,81.24 28.35,81.81 29.68,81.81 30.65,82.78 30.65,122.19 25.55,127.28 9.86,127.28 9.74,127.16 9.74,126.69 9.82,126.6 J2.B7
UTCA_SGMII7_TX_DP: length 112.2
  TOP w0.102: U23.AK19 v6(51.18,58.96)
  L3_SIG1 w0.102: J2.A7 9.15,126.6 9.45,126.89 9.45,127.28 9.74,127.57 25.67,127.57 30.94,122.31 30.94,82.66 29.8,81.52 28.47,81.52 28.07,81.12 28.07,75.66 29.57,74.17 29.57,62.97 32.35,60.19 37.05,60.19 37.73,59.51 37.73,58.31 37.97,58.08 43.92,58.08 44.72,58.88 49.78,58.88 50.22,59.33 50.81,59.33 v6(51.18,58.96)
UTCK: length 1.9
  TOP w0.152: v6(121,106.83) 121,106.85 121.03,106.88 U9.34
  BOTTOM w0.152: v6(121,106.83) 121,106.85 120.64,106.5 R382.1
UTDI: length 3
  TOP w0.152: U9.38 v1(122.3,110.85)
  BOTTOM w0.152: R366.1 122.05,111.89 122.3,111.63 v1(122.3,110.85)
UTDIS: length 5.6
  TOP w0.152: v1(110.87,110.24) 110.87,110.74 110.77,110.85 U9.18
  BOTTOM w0.152: v1(110.87,110.24) R370.1 C358.2 R657.1
UTDO: length 4.4
  TOP w0.152: U9.21 v1(110.87,108.43)
  BOTTOM w0.152: R380.1 110.49,105.92 110.87,106.3 v1(110.87,108.43)
UTMS: length 4.6
  TOP w0.152: v1(122.91,110.87) 122.91,110.26 122.7,110.06 U9.37
  BOTTOM w0.152: v1(122.91,110.87) 122.91,110.88 122.86,110.83 122.86,110.83 122.14,110.11 121.67,110.11 121.48,110.29 R369.1
UTMSK: length 3.1
  TOP w0.152: R118.1 117.63,103.45 116.92,104.17 U9.30
UTRSTN: length 4.2
  TOP w0.152: U9.36 120.27,109.25 119.54,109.98 119.54,109.97 v1(119.61,109.91)
  BOTTOM w0.152: v1(119.61,109.91) 119.54,109.97 119.54,109.98 119.87,109.65 120.8,109.65 R376.1
VAA1: length 9.7
  BOTTOM w0.254: 30.04,30.16 30.23,30.36 U75.28
  BOTTOM w0.381: 30.04,30.16 29.34,29.46 C802.2 C801.1 C800.1 C799.1 FB33.2
VAA2_0: length 11.8
  TOP w0.381: FB11.2 C234.1 C235.1 32.67,27.37 32.63,27.33 32.11,27.33 32.07,27.37 C236.1 C237.2 30.1,28.07 30.84,28.8 30.84,29.82 v3(32.26,31.24)
  BOTTOM w0.203: U75.23 32.97,30.99 32.72,31.24 32.7,31.24 v3(32.26,31.24)
VAA2_1: length 9.9
  TOP w0.381: v3(35.37,31.16) 35.37,29.13 35.85,28.64 C232.2 37.9,28.64 37.93,28.62 C231.1 v1(38.51,29.34)
  BOTTOM w0.203: U75.17 v3(35.37,31.16)
  BOTTOM w0.381: v1(38.51,29.34) C231.1 C229.1 40.35,28.62 FB10.2
VCONT_10: length 23.6
  TOP w0.508: Q9.1 45.94,29.25 45.14,28.45 v3(44.93,28.45)
  L3_SIG1 w0.381: v1(31,32.41) 31.6,33.01 38.85,33.01 40.03,31.83 40.03,29.82 41.59,28.26 42.87,28.26 43.66,29.06 44.32,29.06 44.41,28.97 44.72,28.97 44.84,28.84 44.84,28.54 v3(44.93,28.45)
  BOTTOM w0.203: U75.32 v1(31,32.41)
VER0: length 9.6
  TOP w0.127: v1(140.22,108.88) U15.C4
  TOP w0.152: v1(134.87,112.39) R96.2 R87.1
  BOTTOM w0.152: v1(134.87,112.39) 135.59,112.39 139.1,108.88 v1(140.22,108.88)
VER1: length 7.7
  TOP w0.152: U15.B3 139.42,109.68 139.42,111.6 138.72,112.3 138.02,112.3 137.73,112.6 137.73,113.33 137.52,113.54 R92.2 R78.1
VER2: length 6.8
  TOP w0.152: U15.B4 140.23,109.67 140.23,110.7 140.22,110.72 140.22,111.54 138.23,113.53 R91.2 R77.1
VER3: length 5.2
  TOP w0.152: U15.A4 140.52,110.18 140.52,112.42 140.27,112.67 R90.2 140.27,113.98 140.2,114.05 140.2,114.43 140.27,114.49 R76.1
VPP1V8: length 107.3
  TOP w0.254: U23.M9 v6(66.38,67.76) ; R49.2 v3(108.08,124.97) ; U23.K9 v6(67.98,67.76)
  L10_SIG4 w0.152: 71.57,74.52 71.57,68.39 71.34,68.16 68.59,68.16
  L10_SIG4 w0.165: 68.59,68.16 68.38,68.16 v6(67.98,67.76)
  L10_SIG4 w0.381: 71.57,74.52 71.57,75.05 77.45,80.93 77.45,91.28 72.1,96.63 72.1,101.65 71.21,102.54 71.21,105.93 70.54,106.6 70.54,108.81 67.72,111.63 67.72,113.38 78.94,124.6 87.03,124.6 87.04,124.59 99.14,124.59 100.93,126.38 106.67,126.38 v3(108.08,124.97)
  BOTTOM w0.254: C511.1 v6(66.38,67.76) ; U63.A1 83.11,69.68 82.91,69.48 C478.1 v3(80.21,69.48)
VPP1V8_MON: length 4.4
  TOP w0.152: U4.46 110.72,127.54 110.41,127.22 110.41,125.27 110.11,124.97 R49.1
XDS200_EMU0: length 53.1
  TOP w0.152: v6(120.18,100.23) 120.18,100.62 120.25,100.7 R115.2
  L3_SIG1 w0.107: v6(120.18,100.23) 120.18,100.62 121.38,101.82 121.38,103.29 120.58,104.09 120.58,107.56 120.9,107.88 120.9,121.45 119.13,123.22 115.7,123.22 114.87,124.04 111.69,124.04 110.76,123.11 107.1,123.11 104.77,120.78 102.44,120.78 102.08,121.13 100.05,121.13 98.53,122.66 v1(95.48,122.66)
  BOTTOM w0.152: v1(95.48,122.66) 95.22,122.66 95.02,122.45 U49.10
XDS200_EMU1: length 43.1
  TOP w0.152: v1(112.82,101.23) 112.82,100.82 113.31,100.32 116.87,100.32 118.24,101.69 119.56,101.69 120.42,102.55 R116.2
  BOTTOM w0.152: v1(112.82,101.23) 110.38,101.23 105.84,105.77 105.84,109.55 103.76,111.63 101.21,111.63 99.69,113.16 99.69,122.18 99.09,122.78 96.82,122.78 96.52,122.47 U49.13
XDS200_TCK: length 66.7
  L3_SIG1 w0.107: v1(89.26,123.29) 90.32,124.35 99.61,124.35 102.14,121.82 104.87,121.82 106.44,123.39 108.85,123.39 109.59,124.14 109.73,124.27 114.96,124.27 115.1,124.14 115.79,123.44 119.23,123.44 121.13,121.54 121.13,107.92 121.37,107.69 121.37,105.67 v1(121.06,105.36)
  BOTTOM w0.152: R382.2 120.82,105.59 v1(121.06,105.36) ; U49.3 97.02,117.37 96.45,116.8 94.41,116.8 92.94,118.28 90.61,118.28 90.12,118.77 90.12,122.43 v1(89.26,123.29)
XDS200_TDI: length 47.3
  TOP w0.152: U7.3 v1(84.38,117.97)
  L3_SIG1 w0.107: v1(115.52,110.27) 115.03,109.78 105.46,109.78 103.43,111.81 100.62,111.81 94.89,117.53 94.89,120.7 92.94,122.66 90.1,122.66 88.42,120.98 88.42,120.58 87.12,119.28 85.69,119.28 v1(84.38,117.97)
  BOTTOM w0.152: R366.2 117.13,111.89 v1(115.52,110.27)
XDS200_TDO: length 35.3
  TOP w0.152: U7.13 89.73,117.47 89.92,117.65 89.92,119 v1(89.1,119.81)
  L3_SIG1 w0.107: v1(89.1,119.81) 90.78,121.49 92.91,121.49 94.44,119.96 94.44,113.81 100.43,107.82 102.7,107.82 102.72,107.81 107.71,107.81 v1(108.2,107.31)
  BOTTOM w0.152: v1(108.2,107.31) 108.2,106.05 108.33,105.92 R380.2
XDS200_TMS: length 60.3
  TOP w0.152: R118.2 117.68,102.55 117.03,101.9 v1(117.03,101.9) ; U7.6 v1(83.77,116.47)
  L3_SIG1 w0.107: v1(117.03,101.9) 117.03,101.9 116.18,102.74 116.18,109.04 v1(115.63,109.59) 114.1,108.05 100.52,108.05 94.67,113.91 94.67,120.22 93.17,121.72 90.52,121.72 89.48,120.68 89.13,120.68 87.5,119.05 87.03,119.05 84.45,116.47 v1(83.77,116.47)
  BOTTOM w0.152: R369.2 116.54,110.49 v1(115.63,109.59)
XDS200_TRST#: length 46.9
  TOP w0.152: U7.10 88.72,115.72 88.47,115.47 v1(88.47,115.47)
  L3_SIG1 w0.107: v1(115.53,108.54) 113.93,106.93 107.82,106.93 107.18,107.58 100.35,107.58 94.21,113.72 94.21,119.86 92.81,121.26 91.8,121.26 88.47,117.93 v1(88.47,115.47)
  BOTTOM w0.152: v1(115.53,108.54) 116.09,109.09 R376.2
XDS_1V2: length 34.9
  TOP w0.254: U15.H6 v1(141.82,104.08) ; U15.J6 v1(141.82,103.28) U15.K6 ; U15.E15 v1(149.82,107.28) ; R202.1 C100.1 148.84,76.78 v3(148.69,76.63) ; U15.H7 v1(142.62,104.88) U15.G7 ; v1(148.22,104.88) U15.H14 ; v1(148.22,104.88) U15.G13 ; v1(148.22,104.88) U15.H13 v1(147.42,104.88) U15.H12 v1(146.62,104.88) U15.H11 v1(145.82,104.88) U15.H10 ; U15.M9 v1(144.22,100.88) U15.N8 ; U15.M12 v1(147.42,101.68) U15.L12 v1(147.42,102.48) U15.K12 v1(147.42,103.28) U15.J12 ; U15.L14 v1(149.02,101.68) ; U15.M8 v1(143.42,100.88) U15.N7 ; v1(141.82,107.28) U15.E5 ; v1(143.42,105.68) U15.G8
  BOTTOM w0.254: C386.1 146.66,101.73 v1(147.42,102.48) ; v1(143.42,105.68) 143.21,105.48 C378.1 142.66,104.93 v1(142.62,104.88) ; C393.1 143.15,100.2 143.42,100.47 v1(143.42,100.88) ; C392.1 144.02,100.69 v1(144.22,100.88) ; v1(141.82,107.28) 141.18,106.64 C366.1 140.38,106.64 v1(140.22,106.48) 139.8,106.9 C367.1 ; v1(145.82,104.88) 145.54,104.61 145.54,103.88 145.18,103.52 C381.1 ; v1(141.82,104.08) 142.37,104.08 142.53,103.93 C382.1 142.46,103.28 v1(141.82,103.28) ; v1(147.42,101.68) 147.05,101.32 146.91,101.32 146.66,101.07 C390.1 ; C385.1 v1(153.85,103.86) ; v1(149.82,107.28) 150.47,107.28 C369.1 ; v1(147.42,104.88) 147.03,104.5 C380.1 147.03,103.67 v1(147.42,103.28)
  vias: v3(131.07,87.38) v3(131.08,86.42) v3(131.88,87.38) v3(131.93,86.42) v3(132.51,78.94) v3(132.49,77.77) v3(133.35,78.94) v3(133.32,77.77) v3(163.68,93.57) v3(163.7,92.79) v3(164.54,92.81)
XDS_1V8: length 21.6
  TOP w0.254: U15.F14 v1(148.22,106.48) ; U15.G11 v1(146.62,105.68) U15.G12 ; U15.L6 v1(141.82,102.48) U15.K5 ; U15.R13 v1(147.42,99.28) U15.P13 ; U15.J13 v1(148.22,104.08) ; v1(110.9,112.52) 110.9,112.98 110.64,113.23 U9.15 ; v3(149.72,86.63) v3(149.72,85.87) ; R122.2 v3(112.37,101.85) ; U15.G6 v1(141.82,104.88) ; U15.G10 v1(145.82,105.68)
  BOTTOM w0.254: v3(161.66,84.91) 161.42,84.91 161.22,84.71 R415.1 U61.3 ; v1(148.22,104.08) 148.76,104.63 C377.1 ; C399.1 147.57,99.13 v1(147.42,99.28) ; v1(141.82,102.48) 141.71,102.38 C387.1 ; C364.1 145.66,105.84 v1(145.82,105.68) ; v1(146.62,105.68) 146.76,105.82 C370.1 147.56,105.82 v1(148.22,106.48) ; C354.1 109.15,112.77 109.4,112.52 v1(110.9,112.52) ; v1(141.82,104.88) 141.47,104.54 140.83,104.54 140.81,104.52 C379.1 ; FB19.1 v3(149.72,86.63)
  vias: v3(145.21,92.68) v3(145.21,91.92) v3(145.97,92.68) v3(145.97,91.92) v3(154.23,81.99) v3(154.25,82.96) v3(155.14,81.99) v3(155.17,82.96)
XDS_BOOTMODE[0]: length 10.7
  TOP w0.152: R175.2 138.67,89.88 139.14,90.35 139.14,91.82 138.92,92.04 R168.1 138.51,93.52 139.37,94.39 140.36,94.39 141,95.02 141,96.67 140.77,96.9 140.2,96.9 U15.U3
XDS_BOOTMODE[1]: length 6.9
  TOP w0.152: R153.2 R152.1 133.28,97.62 133.73,97.18 136.98,97.18 137.88,98.08 U15.T1
XDS_BOOTMODE[2]: length 7.9
  TOP w0.152: U15.T2 138.62,97.69 137.92,97.69 136.93,96.7 133.67,96.7 133.28,96.3 R158.1 R159.2
XDS_BOOTMODE[3]: length 10.4
  TOP w0.152: U15.T3 139.4,97.66 139.4,97.45 139.4,97.44 139.4,97.13 139.4,97.12 139.4,96.64 139.4,96.64 139.4,96.33 139.4,96.32 139.4,95.85 139.4,95.84 139.4,95.53 139.4,95.52 139.4,95.05 137.03,92.68 R169.1 136.72,92.04 136.39,91.71 136.39,90.05 136.55,89.88 R176.2
XDS_BOOTMODE[4]: length 7.5
  TOP w0.152: R142.2 R141.2 133.3,101.07 133.3,100.48 133.78,100 134.34,100 134.51,99.84 136.18,99.84 137.13,98.88 U15.R1
XDS_BOOTMODE[5]: length 9.6
  TOP w0.152: R126.2 R125.2 133.28,102.3 133.48,102.1 135.73,102.1 135.99,101.84 135.99,100.5 137.19,99.3 138.6,99.3 U15.R2
XDS_BOOTMODE[6]: length 8.7
  TOP w0.127: v1(139.42,98.48) U15.R3
  TOP w0.152: v1(139.42,98.48) 133.67,98.48 133.28,98.88 R148.2 R149.2
XDS_BOOTMODE[7]: length 11.9
  TOP w0.152: U15.P4 140.2,100.1 137.03,100.1 136.49,100.64 136.49,101.77 135.98,102.28 135.98,102.88 135.26,103.61 133.5,103.61 133.28,103.83 R110.2 R111.2
XDS_RTCK: length 24.3
  L8_SIG3 w0.107: v1(108.2,105.03) 107.59,105.64 102.81,105.64 102.15,106.29 102.15,107.93 100.05,110.03 98.04,110.03 97.94,110.13 97.94,110.16 95.02,113.09 95.02,116.25 95.52,116.75 95.52,117.52 95.54,117.52 v1(95.54,117.52)
  BOTTOM w0.152: U49.6 95.52,117.52 95.54,117.52 v1(95.54,117.52) ; v1(108.2,105.03) 109.02,105.03 109.15,104.89 R383.2
XDS_SYS_RESETN: length 2.8
  TOP w0.152: U19.1 155.64,91.34 155.64,93.12 v3(155.68,93.15)
  BOTTOM w0.152: R396.1 v3(155.68,93.15)
XDS_USB_DM: length 23.5
  TOP w0.114: U15.M18 v1(152.22,100.88)
  L10_SIG4 w0.102: v3(167.84,100.62) 167.6,100.87 161.76,100.87 160.9,100.01 152.9,100.01 152.51,100.4 152.51,100.59 v1(152.22,100.88)
  BOTTOM w0.114: J3.2 170.87,100.5 170.51,100.86 168.08,100.86 v3(167.84,100.62) 167.62,100.84 167.32,100.84 167.2,100.72 D14.2
XDS_USB_DP: length 23.5
  TOP w0.114: U15.M19 v1(153.02,100.88)
  L10_SIG4 w0.102: v1(153.02,100.88) 152.72,100.59 152.72,100.49 152.99,100.23 159.41,100.23 159.51,100.33 159.74,100.33 159.84,100.23 160.07,100.23 160.17,100.33 160.4,100.33 160.5,100.23 160.81,100.23 161.67,101.08 161.94,101.08 162.18,101.32 162.41,101.32 162.65,101.08 162.88,101.08 163.11,101.32 163.34,101.32 163.58,101.08 163.81,101.08 164.05,101.32 164.27,101.32 164.51,101.08 164.74,101.08 164.98,101.32 165.21,101.32 165.45,101.08 165.67,101.08 165.91,101.32 166.14,101.32 166.38,101.08 166.61,101.08 166.84,101.32 167.07,101.32 167.31,101.08 167.6,101.08 v3(167.84,101.33)
  BOTTOM w0.114: D14.1 167.15,101.22 167.31,101.07 167.58,101.07 v3(167.84,101.33) 168.08,101.09 168.9,101.09 169.06,101.24 169.3,101.24 169.45,101.09 169.69,101.09 169.85,101.24 170.09,101.24 170.25,101.09 170.56,101.09 170.77,101.3 J3.3
XDS_USB_GND: length 21.3
  BOTTOM w0.305: 166.25,99.64 D14.4
  BOTTOM w0.381: 175.33,98.68 J3.6 ; J3.6 175.33,96.62 ; J3.6 178.37,96.62 ; 175.33,103.92 J3.7 ; J3.7 175.33,105.98 ; J3.7 178.37,105.98 ; 166.25,99.64 166.25,98.85 166.45,98.65 175.06,98.65
XDS_USB_VBUS: length 132.7
  TOP w0.254: v5(154.04,96.01) 154.59,96.01 154.91,96.33 R156.2 ; U19.6 C67.1 v3(154.64,87.19) ; R203.2 v3(146.05,76.53) ; R191.2 v3(138.49,84.91)
  L3_SIG1 w0.254: 165.91,96.01 v3(165.94,96.04)
  BOTTOM w0.254: R343.2 v3(86.11,120.6) 87.22,121.72 87.22,122.25 89.22,124.25 91.16,124.25 91.44,124.53 99.4,124.53 100.23,123.7 100.23,113.39 101.52,112.09 103.95,112.09 106.01,110.03 106.3,109.74 106.3,105.95 109.74,102.51 113,102.51 115.72,99.79 115.72,90.14 120.23,85.64 137.99,85.64 v3(138.48,86.13)
  BOTTOM w0.381: v3(138.49,84.91) 142.31,84.91 v3(142.54,85.14) ; v3(138.49,84.91) 138.49,86.12 v3(138.48,86.13) ; v3(138.49,84.91) 138.47,84.89 137.36,84.89 136.49,84.02 136.49,79.47 139.02,76.94 v3(143.81,76.94) 144.06,76.7 144.06,76.67 144.45,76.27 145.79,76.27 v3(146.05,76.53) 146.05,80.09 v3(148.97,83.01) 149,83.03 v3(149,83.9) 149.45,83.9 153.44,87.88 C435.1 ; C435.1 154.06,87.44 154.31,87.19 v3(154.64,87.19) ; C435.1 154.06,88.55 153.91,88.7 U59.5
  vias: v3(165.96,96.85)
XDS_VBUS: length 0.6
  BOTTOM w0.254: D14.6 v3(166.25,101.83)
XDS_VCC3V3: length 112.8
  TOP w0.127: v6(123.57,108.24) 123.46,108.35 123.46,108.38
  TOP w0.254: U9.35 119.53,108.43 v1(119.4,108.56) ; R96.1 v1(132.66,112.39) ; U15.J5 v1(141.02,104.08) U15.H5 ; R72.1 v1(142.62,118.11) ; U15.F6 v1(142.62,105.68) U15.F7 ; U15.M13 v1(147.42,100.88) U15.N13 ; v1(155.5,112.19) 155.5,112.32 156.41,111.41 R97.1 ; U19.5 154.56,87.96 154,87.4 v3(154,86.56) ; v6(125.74,104.47) 125.51,104.24 C863.1 ; U15.P5 v1(141.82,99.28) U15.P6 ; v1(149.02,107.28) U15.E14 ; R110.1 v1(135.12,104.39) ; U15.L13 v1(148.22,102.48) U15.K13 ; C862.1 125.8,107.74 v6(125.74,107.67) ; U15.G5 v1(141.02,105.68) U15.F5 ; C860.1 126.1,105.71 v6(125.74,106.07) ; v1(134.78,99.24) 134.63,99.38 134.32,99.38 134.26,99.44 R148.1 ; U5.8 v3(149.86,120.14) ; R152.2 v1(134.8,97.79) ; U15.J14 v1(149.02,104.08) ; U15.F8 v1(144.22,105.68) 144.62,105.29 U15.G9 ; v6(128.77,107.27) 128.76,107.26 C861.1 ; R114.2 v3(163.58,103) ; U15.K15 v1(149.82,102.48) ; U15.F10 v1(145.82,106.48) U15.F11 v1(146.62,106.48) U15.F12 ; R166.2 150.88,90.5 151.18,90.2 v3(151.64,90.2) ; R101.1 v1(156.41,110.45) ; R185.2 143.69,83.97 143.9,83.77 U20.15 ; R123.2 v3(110.97,101.93) ; v3(137.77,90.47) 137.26,90.47 137.03,90.7 R169.2 R168.2 ; TP10.1 v3(114.53,118.62) U9.7 ; U15.G14 v1(148.22,105.68) U15.F13 ; U15.G15 v1(149.82,105.68) U15.F15 ; v1(139.13,114.35) R91.1 ; R141.1 134.64,101.09 134.9,100.83 134.9,100.82 v1(134.91,100.81) ; R125.1 134.54,102.74 v1(134.73,102.93) ; v1(140.22,98.48) U15.R4 ; R158.2 v1(134.82,96.14) ; R92.1 v1(135.48,113.54) ; v1(146.62,99.28) U15.P12 ; R90.1 v1(141.17,112.78) ; v6(128.77,105.67) 128.33,105.23 C864.1 ; v1(141.02,102.48) U15.L4 ; C865.1 123.46,108.38
  BOTTOM w0.254: v1(141.02,104.08) 140.69,104.08 140.25,103.65 C383.1 140.25,102.87 140.64,102.48 v1(141.02,102.48) ; v1(148.22,105.68) 148.86,106.33 C359.1 148.86,107.13 v1(149.02,107.28) ; v1(145.82,106.48) 145.82,107.16 C363.1 ; v3(114.53,118.62) C350.1 C349.1 ; U78.A7 v6(125.74,107.67) ; C372.1 140.23,105.68 v1(141.02,105.68) ; v1(148.22,102.48) 148.22,101.48 C388.1 147.95,101.42 v1(147.42,100.88) ; U78.E7 v6(125.74,104.47) ; 157.54,110.4 R374.2 ; 157.54,110.4 157.59,110.45 157.59,110.94 157.88,111.23 172.75,111.23 173.02,110.95 R373.2 v3(174.09,110.18) R372.2 v3(176.22,110.18) R371.2 ; 157.54,110.4 v1(157.54,110.45) ; C365.1 143.59,106.31 v1(144.22,105.68) ; U78.C7 v6(125.74,106.07) ; v1(140.22,98.48) 140.3,98.57 C402.1 141.53,99 v1(141.82,99.28) ; R362.2 v1(154.33,113.47) ; R363.1 v1(152.68,113.47) ; v1(146.62,99.28) 146.43,99.1 C400.1 ; R355.2 R352.2 150.5,117.09 150.37,116.97 v3(149.86,116.97) ; R598.2 v1(148.69,116.22) ; U78.B3 v6(128.77,107.27) ; v3(110.05,116.84) R354.2 ; v3(149.86,120.14) C347.1 R346.2 ; U78.J9 v6(123.17,100.87) ; C373.1 149.97,105.53 v1(149.82,105.68) ; R409.2 v3(161.54,88.27) ; v1(149.02,104.08) 149.13,104.08 149.82,103.4 C384.1 v1(149.82,102.48) ; v1(111.48,112.12) 111.58,112.01 111.58,111.24 111.24,110.9 110.34,110.9 110.05,111.18 R367.1 ; R397.1 v3(152.68,93.15) ; U78.D3 v6(128.77,105.67) ; U78.A9 v6(123.57,108.24) ; R350.2 v3(113.13,118.62) ; v3(144.65,120.27) R342.2 R345.2 ; v1(119.4,108.56) 119.53,108.43 120.62,108.43 C362.1 ; R398.2 v3(151.64,90.2) ; v1(156.41,110.45) R101.1
  vias: v1(135.71,97.76) v1(136.84,97.76) v3(122.02,100.23) v3(122.02,98.84) v3(144.48,89.28) v3(144.48,88.37) v3(145.24,89.28) v3(145.24,88.37) v3(165.28,99.82) v3(165.28,98.98) v3(165.28,98.17)
XFICLKN: length 41.4
  TOP w0.102: U23.AJ12 v6(51.98,65.36) ; v3(60.05,89.99) 60.31,90.25 60.63,90.25 60.84,90.04 R673.2
  L8_SIG3 w0.102: v6(51.98,65.36) 51.55,65.79 50.23,65.79 49.95,66.07 49.66,66.07 47.03,68.69 47.03,74.8 48.08,75.86 52.82,75.86 57.96,81 57.96,83.03 59.19,84.25 59.19,85.19 59.82,85.81 61.42,85.81 62.52,86.91 62.52,88.72 60.95,90.3 60.36,90.3 v3(60.05,89.99)
XFICLKN_R: length 4.1
  TOP w0.152: U18.15 64.61,91.31 64.61,90.44 64.15,89.98 62.5,89.98 62.36,90.12 61.92,90.12 R673.1
XFICLKP: length 41.4
  TOP w0.102: U23.AJ11 v6(51.98,66.16) ; R672.2 60.84,90.82 60.52,90.5 60.36,90.5 v3(60.05,90.81)
  L8_SIG3 w0.102: v6(51.98,66.16) 51.6,66.54 49.6,66.54 47.32,68.82 47.32,74.68 48.2,75.56 52.94,75.56 58.25,80.88 58.25,82.91 59.48,84.13 59.48,85.07 59.94,85.52 61.54,85.52 62.81,86.79 62.81,88.84 61.07,90.59 60.27,90.59 v3(60.05,90.81)
