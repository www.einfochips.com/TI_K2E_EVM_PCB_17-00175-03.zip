# Allegro board TI_K2E_EVM_PCB_17-00175-03.brd (continued)
## Library data of the parts (continued)
C1-C100 C102 C103 C105 C106 C112-C114 C117 C120-C122 C124-C161 C163 C164 C166-C175 C177-C186 C188-C252 C254 C256 C257 C259-C433 C435-C439 C441-C479 C481-C487 C489-C506 C508-C518 C520-C532 C534-C551 C554-C564 C566-C572 C574-C576 C578-C584 C586-C594 C596-C598 C600-C606 C608 C609 C611-C633 C635-C648 C650-C661 C664-C670 C672-C683 C685-C690 C692-C768 C772-C781 C783-C866 C872 C874-C876 C881-C899 = Cap_Ceramic
C101 C104 C107-C111 C115 C116 C118 C119 C123 C162 C165 C176 C187 C573 C585 C599 C607 C610 C634 C649 C662 C769-C771 C782 = Cap_Ceramic: signal model: CAP_CERAMIC_C0402_DISCRETE_100N_100nF
C480 C488 C507 C519 C533 C552 C553 C565 C577 C595 C663 C671 C684 C691 = Cap_Ceramic: room: CPU1
CN1 CN6 = 1653_JH3X1V-2M_0
CN2 = 1654_PWR_2P_5223957-3_0
CN3 = 1653_HD_5X2P_0
CN4 = 1653_HD_2P_D_0
CN5 = 1653_JH6X1V-2M_0
CN7 = CONN_Expansion
COM1 COM2 = CONNECTOR - 3 X 1_0
CT1-CT8 = CAP POL
CVDD CVDD1 GND1-GND4 GNDC TP1-TP13 TP15-TP98 UNK0V85 UNK1V8 UNK3V3 = 00_TP-S40_0
D1 D2 = 130_SCHOTTKY_ANODE2_0
D3 = 130_LED_2P_R_KPA-1606EC_0
D4 DBG_D2 DBG_D3 = 130_LED_2P_B_KPA-1606QBC-D_0
D5 = 130_LED_LED-0603_R_0
D6 = 130_LED_LED-0603_G_0
D7-D9 = SMF-2432GC_1: Tolerance: X; User Part Number: X
D10 = LED
D11 D15 = Schottky Diode
D12 = Zener Diode
D13 = TPD4S012DRY
D14 = 130_TVS_SON6_TPD4S012DRY_0
DBG_D1 = 130_LED_3P_KPBA-3010ESGC_0
DIMM1 = 2013289-1_DDR3-SODIMM_204P
EEPROM1 = M24M01-HRMN6TP
EMU1 = CONN_MIPI-60
ESD1 = AMC-ESD-B_0
F1 = Fuse
FAN1 = 12_WF_4P_BOX_D_0
FB1-FB16 FB20-FB39 = 1212_BEAD_0
FB17-FB19 = NFM_3
FM1-FM6 = Fiducial
H1-H3 H5 = 00_SCREWHOLE_CIRCLE_NPTH_1
H4 = 00_SCREWHOLE_OVAL_NPTH_0
H6 = H27P35-MTH_0
J1 J3 = Mini USB Connector_0
J2 = ATCA_160P_2
J4 = ATCA_160P_1
J5 = HEADER 10X2_0
J6 = KMMX-AB10-SMT4SB30TR
J7 = 10117835-001LF_0
J8 = CONN_SATA_PWR
J9 = XMH-TRJG17020AENL
J10 = ESATA_Connector_0
J11 = Power Jack_1
L1 L2 L6 L10-L14 = 1211_CHOKE_0
L3-L5 L7-L9 = CHOKE CM_0
LCD1 = 968_LCD_17P_NHD-C12832A1Z_0
NOR1 = N25Q128A11BSF40F_3
OSC1 = 1233_OSC_4P_0
PMBUS1 = 1653_JH5X1V_0
Q1 = MCP9700AT
Q2 = TLV1117
Q3-Q6 Q11-Q14 = 131_SOT-23A_BEC_0
Q7 Q8 = NTA4153N
Q9 = BCP69T1G_4
Q10 = 131_REG_SOT-23_APL431LBAI_0
Q15 = TPS73701DRBT
R1-R23 R25-R78 R81-R85 R87-R282 R284-R403 R407 R409 R412 R415 R417-R475 R477-R480 R482-R509 R513-R564 R566-R595 R598 R601-R615 R621 R623-R632 R634-R640 R642-R666 R668 R669 R671-R677 = 10_R_0
R79 R283 R476 R481 R596 R597 R599 R600 = 10_R_0: signal model: 10_R_0_R0402_DISCRETE_22E__22E
R414 R416 = 10_R_0: signal model: 10_R_0_R0402_DISCRETE_22E_22E
RN1 RN3-RN9 = R-Pak4: signal model: R-PAK4_RESN_EXBN8V_0402X4_RPACK_RPACK4-22
RN2 = R-Pak4
RST_ATTN1 = SW_2
RST_BMC1 = SW_3
RST_PWR1 = SW_1
RV1 = VARISTOR: User Part Number: X; Tolerance: X
SW1 = 160_SW_8P_ESD104EZ_0
TP14 = TEST POINT
U1 = LM3S2D93-IQC80
U2 = CP2105_3
U3 U55 = 74LVC2G125DC,125
U4 = UCD9090
U5 = SPI_EEPROM_2
U6 U10 U51 U54 = SN74AUCH244RGYR_0
U7 U49 = TS3L110
U8 U39 U43 U44 = MCP23S17T
U9 = xc2c32a_vq44
U11 U68 = TXS0104
U12 U59 U81 = SN74LVC1G06DRLR_1
U13 U36 = SN74LVC1G11DCKR
U14 U16 = SN74AUCH245RGYR
U15 = AM1802
U17 U18 = CDCM6208V1
U19 = TPS3808G
U20 = TPS65000
U21 U64 U66 U71 = PCA9517
U22 U25 = TPS54620RGY
U23 = K2E_Processor_4
U24 U30 = SP3012-06UTG
U26 U32 = TPS2065CDBVR
U27 U31 = SN74LVC1G07
U28 U29 U62 U63 = TPS22913B
U33 = LM26430
U34 = TPS544B20
U35 = LM10011SD
U37 U58 U79 = TXS0102
U38 = SN74AVC4T245PWR
U40 U41 U45 U46 = TXS0108EPWR
U42 U52 = SN74LVC2G157
U47 U50 = MAX3221
U48 = SN74LVC125A_3
U53 = MT29F4G08ABBDAHCD
U56 = SN74LVC1T45DCKR
U57 = SN74LVC244
U61 = TLV431ACDBVR: Tolerance: X; User Part Number: X
U65 = ICS557GI-08LFT_0
U67 U69 = PCA9306DCUT
U70 U72 = ICS83026I-01
U73 U77 = 88E1512
U74 = TPS51200DRCT_0
U75 = 88SE9182
U76 = AT26F004
U78 = MT48LC4M16A2B4
U80 = SN74LVC8T245_2
Y1 = Crystal_2Pin_2
Y2 = CRYSTAL_0
Y3 = Crystal_2Pin
Y4 = OSC4/SM_0
Y5-Y8 = CRYSTAL-4 PIN

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
ACM2012
  rect 0.762x0.406 smd: 1(-0.925,0.4) 2(-0.925,-0.4) 3(0.925,-0.4) 4(0.925,0.4)
AMC-ESD-B
  custom 1.175x1.175 smd: 1(0,-0.3)
  custom 0.25x0.25 smd: 2(-125.5,1.55) 3(-138.5,1.55)
  round 3.2 hole 2.692: 4(0,0)
ATCA_160P_384312
  rect 0.864x0.864 hole 0.457: A1(11.25,1.1)
  round 0.864 hole 0.457: A2(8.75,1.1) A3(6.25,1.1) A4(3.75,1.1) A5(1.25,1.1) A6(-1.25,1.1) A7(-3.75,1.1) A8(-6.25,1.1) A9(-8.75,1.1) A10(-11.25,1.1) B1(11.25,2.3) B2(8.75,2.3) B3(6.25,2.3) B4(3.75,2.3) B5(1.25,2.3) B6(-1.25,2.3) B7(-3.75,2.3) B8(-6.25,2.3) B9(-8.75,2.3) B10(-11.25,2.3) C1(11.25,5.6) C2(8.75,5.6) C3(6.25,5.6) C4(3.75,5.6) C5(1.25,5.6) C6(-1.25,5.6) C7(-3.75,5.6) C8(-6.25,5.6) C9(-8.75,5.6) C10(-11.25,5.6) D1(11.25,6.8) D2(8.75,6.8) D3(6.25,6.8) D4(3.75,6.8) D5(1.25,6.8) D6(-1.25,6.8) D7(-3.75,6.8) D8(-6.25,6.8) D9(-8.75,6.8) D10(-11.25,6.8) E1(11.25,10.1) E2(8.75,10.1) E3(6.25,10.1) E4(3.75,10.1) E5(1.25,10.1) E6(-1.25,10.1) E7(-3.75,10.1) E8(-6.25,10.1) E9(-8.75,10.1) E10(-11.25,10.1) F1(11.25,11.3) F2(8.75,11.3) F3(6.25,11.3) F4(3.75,11.3) F5(1.25,11.3) F6(-1.25,11.3) F7(-3.75,11.3) F8(-6.25,11.3) F9(-8.75,11.3) F10(-11.25,11.3) G1(11.25,14.6) G2(8.75,14.6) G3(6.25,14.6) G4(3.75,14.6) G5(1.25,14.6) G6(-1.25,14.6) G7(-3.75,14.6) G8(-6.25,14.6) G9(-8.75,14.6) G10(-11.25,14.6) GA1(10.21,0) GA2(7.71,0) GA3(5.21,0) GA4(2.71,0) GA5(0.21,0) GA6(-2.29,0) GA7(-4.79,0) GA8(-7.29,0) GA9(-9.79,0) GA10(-12.29,0) GH1(11.25,17) GH2(8.75,17) GH3(6.25,17) GH4(3.75,17) GH5(1.25,17) GH6(-1.25,17) GH7(-3.75,17) GH8(-6.25,17) GH9(-8.75,17) GH10(-11.25,17) H1(11.25,15.8) H2(8.75,15.8) H3(6.25,15.8) H4(3.75,15.8) H5(1.25,15.8) H6(-1.25,15.8) H7(-3.75,15.8) H8(-6.25,15.8) H9(-8.75,15.8) H10(-11.25,15.8)
  round 0.711 hole 0.457: GB1(11.25,3.5) GB2(8.75,3.5) GB3(6.25,3.5) GB4(3.75,3.5) GB5(1.25,3.5) GB6(-1.25,3.5) GB7(-3.75,3.5) GB8(-6.25,3.5) GB9(-8.75,3.5) GB10(-11.25,3.5) GC1(11.25,4.4) GC2(8.75,4.4) GC3(6.25,4.4) GC4(3.75,4.4) GC5(1.25,4.4) GC6(-1.25,4.4) GC7(-3.75,4.4) GC8(-6.25,4.4) GC9(-8.75,4.4) GC10(-11.25,4.4) GD1(11.25,8) GD2(8.75,8) GD3(6.25,8) GD4(3.75,8) GD5(1.25,8) GD6(-1.25,8) GD7(-3.75,8) GD8(-6.25,8) GD9(-8.75,8) GD10(-11.25,8) GE1(11.25,8.9) GE2(8.75,8.9) GE3(6.25,8.9) GE4(3.75,8.9) GE5(1.25,8.9) GE6(-1.25,8.9) GE7(-3.75,8.9) GE8(-6.25,8.9) GE9(-8.75,8.9) GE10(-11.25,8.9) GF1(11.25,12.5) GF2(8.75,12.5) GF3(6.25,12.5) GF4(3.75,12.5) GF5(1.25,12.5) GF6(-1.25,12.5) GF7(-3.75,12.5) GF8(-6.25,12.5) GF9(-8.75,12.5) GF10(-11.25,12.5) GG1(11.25,13.4) GG2(8.75,13.4) GG3(6.25,13.4) GG4(3.75,13.4) GG5(1.25,13.4) GG6(-1.25,13.4) GG7(-3.75,13.4) GG8(-6.25,13.4) GG9(-8.75,13.4) GG10(-11.25,13.4)
BB_30X2P_20_838X285_F
  round 1.016 hole 1.016 unplated: (-10.065,2.67) (10.065,2.67)
  oval 0.279x2.286 smd: 1(-7.25,-2.87) 2(-7.25,2.87) 3(-6.75,-2.87) 4(-6.75,2.87) 5(-6.25,-2.87) 6(-6.25,2.87) 7(-5.75,-2.87) 8(-5.75,2.87) 9(-5.25,-2.87) 10(-5.25,2.87) 11(-4.75,-2.87) 12(-4.75,2.87) 13(-4.25,-2.87) 14(-4.25,2.87) 15(-3.75,-2.87) 16(-3.75,2.87) 17(-3.25,-2.87) 18(-3.25,2.87) 19(-2.75,-2.87) 20(-2.75,2.87) 21(-2.25,-2.87) 22(-2.25,2.87) 23(-1.75,-2.87) 24(-1.75,2.87) 25(-1.25,-2.87) 26(-1.25,2.87) 27(-0.75,-2.87) 28(-0.75,2.87) 29(-0.25,-2.87) 30(-0.25,2.87) 31(0.25,-2.87) 32(0.25,2.87) 33(0.75,-2.87) 34(0.75,2.87) 35(1.25,-2.87) 36(1.25,2.87) 37(1.75,-2.87) 38(1.75,2.87) 39(2.25,-2.87) 40(2.25,2.87) 41(2.75,-2.87) 42(2.75,2.87) 43(3.25,-2.87) 44(3.25,2.87) 45(3.75,-2.87) 46(3.75,2.87) 47(4.25,-2.87) 48(4.25,2.87) 49(4.75,-2.87) 50(4.75,2.87) 51(5.25,-2.87) 52(5.25,2.87) 53(5.75,-2.87) 54(5.75,2.87) 55(6.25,-2.87) 56(6.25,2.87) 57(6.75,-2.87) 58(6.75,2.87) 59(7.25,-2.87) 60(7.25,2.87)
  rect 4.699x0.635 smd: H3(-3.175,0) H4(3.175,0)
  rect 2.54x0.635 smd: H5(8.065,0) H6(-8.065,0)
BB_60X2P_20_2225X285_F
  round 1.016 hole 1.016 unplated: (-20.065,2.67) (20.065,2.67)
  oval 0.279x2.286 smd: 1(-17.25,-2.87) 2(-17.25,2.87) 3(-16.75,-2.87) 4(-16.75,2.87) 5(-16.25,-2.87) 6(-16.25,2.87) 7(-15.75,-2.87) 8(-15.75,2.87) 9(-15.25,-2.87) 10(-15.25,2.87) 11(-14.75,-2.87) 12(-14.75,2.87) 13(-14.25,-2.87) 14(-14.25,2.87) 15(-13.75,-2.87) 16(-13.75,2.87) 17(-13.25,-2.87) 18(-13.25,2.87) 19(-12.75,-2.87) 20(-12.75,2.87) 21(-12.25,-2.87) 22(-12.25,2.87) 23(-11.75,-2.87) 24(-11.75,2.87) 25(-11.25,-2.87) 26(-11.25,2.87) 27(-10.75,-2.87) 28(-10.75,2.87) 29(-10.25,-2.87) 30(-10.25,2.87) 31(-9.75,-2.87) 32(-9.75,2.87) 33(-9.25,-2.87) 34(-9.25,2.87) 35(-8.75,-2.87) 36(-8.75,2.87) 37(-8.25,-2.87) 38(-8.25,2.87) 39(-7.75,-2.87) 40(-7.75,2.87) 41(-7.25,-2.87) 42(-7.25,2.87) 43(-6.75,-2.87) 44(-6.75,2.87) 45(-6.25,-2.87) 46(-6.25,2.87) 47(-5.75,-2.87) 48(-5.75,2.87) 49(-5.25,-2.87) 50(-5.25,2.87) 51(-4.75,-2.87) 52(-4.75,2.87) 53(-4.25,-2.87) 54(-4.25,2.87) 55(-3.75,-2.87) 56(-3.75,2.87) 57(-3.25,-2.87) 58(-3.25,2.87) 59(-2.75,-2.87) 60(-2.75,2.87) 61(2.75,-2.87) 62(2.75,2.87) 63(3.25,-2.87) 64(3.25,2.87) 65(3.75,-2.87) 66(3.75,2.87) 67(4.25,-2.87) 68(4.25,2.87) 69(4.75,-2.87) 70(4.75,2.87) 71(5.25,-2.87) 72(5.25,2.87) 73(5.75,-2.87) 74(5.75,2.87) 75(6.25,-2.87) 76(6.25,2.87) 77(6.75,-2.87) 78(6.75,2.87) 79(7.25,-2.87) 80(7.25,2.87) 81(7.75,-2.87) 82(7.75,2.87) 83(8.25,-2.87) 84(8.25,2.87) 85(8.75,-2.87) 86(8.75,2.87) 87(9.25,-2.87) 88(9.25,2.87) 89(9.75,-2.87) 90(9.75,2.87) 91(10.25,-2.87) 92(10.25,2.87) 93(10.75,-2.87) 94(10.75,2.87) 95(11.25,-2.87) 96(11.25,2.87) 97(11.75,-2.87) 98(11.75,2.87) 99(12.25,-2.87) 100(12.25,2.87) 101(12.75,-2.87) 102(12.75,2.87) 103(13.25,-2.87) 104(13.25,2.87) 105(13.75,-2.87) 106(13.75,2.87) 107(14.25,-2.87) 108(14.25,2.87) 109(14.75,-2.87) 110(14.75,2.87) 111(15.25,-2.87) 112(15.25,2.87) 113(15.75,-2.87) 114(15.75,2.87) 115(16.25,-2.87) 116(16.25,2.87) 117(16.75,-2.87) 118(16.75,2.87) 119(17.25,-2.87) 120(17.25,2.87)
  rect 4.699x0.635 smd: H3(-13.175,0) H4(-6.825,0) H7(6.825,0) H8(13.175,0)
  rect 2.54x0.635 smd: H5(-1.935,0) H6(-18.065,0) H9(18.065,0) H10(1.935,0)
  round 6.35 hole 3.962: H11(-24.33,0) H12(24.33,0)
BERG_1X3
  rect 1.448x1.448 hole 1.016: 1(0,0)
  round 1.448 hole 1.016: 2(2.54,0) 3(5.08,0)
BGA80P_16X16_361
  round 1.016 smd: (-9,9) (9,-9)
  round 0.406 smd: A1(-7.2,7.2) A2(-6.4,7.2) A3(-5.6,7.2) A4(-4.8,7.2) A5(-4,7.2) A6(-3.2,7.2) A7(-2.4,7.2) A8(-1.6,7.2) A9(-0.8,7.2) A10(0,7.2) A11(0.8,7.2) A12(1.6,7.2) A13(2.4,7.2) A14(3.2,7.2) A15(4,7.2) A16(4.8,7.2) A17(5.6,7.2) A18(6.4,7.2) A19(7.2,7.2) B1(-7.2,6.4) B2(-6.4,6.4) B3(-5.6,6.4) B4(-4.8,6.4) B5(-4,6.4) B6(-3.2,6.4) B7(-2.4,6.4) B8(-1.6,6.4) B9(-0.8,6.4) B10(0,6.4) B11(0.8,6.4) B12(1.6,6.4) B13(2.4,6.4) B14(3.2,6.4) B15(4,6.4) B16(4.8,6.4) B17(5.6,6.4) B18(6.4,6.4) B19(7.2,6.4) C1(-7.2,5.6) C2(-6.4,5.6) C3(-5.6,5.6) C4(-4.8,5.6) C5(-4,5.6) C6(-3.2,5.6) C7(-2.4,5.6) C8(-1.6,5.6) C9(-0.8,5.6) C10(0,5.6) C11(0.8,5.6) C12(1.6,5.6) C13(2.4,5.6) C14(3.2,5.6) C15(4,5.6) C16(4.8,5.6) C17(5.6,5.6) C18(6.4,5.6) C19(7.2,5.6) D1(-7.2,4.8) D2(-6.4,4.8) D3(-5.6,4.8) D4(-4.8,4.8) D5(-4,4.8) D6(-3.2,4.8) D7(-2.4,4.8) D8(-1.6,4.8) D9(-0.8,4.8) D10(0,4.8) D11(0.8,4.8) D12(1.6,4.8) D13(2.4,4.8) D14(3.2,4.8) D15(4,4.8) D16(4.8,4.8) D17(5.6,4.8) D18(6.4,4.8) D19(7.2,4.8) E1(-7.2,4) E2(-6.4,4) E3(-5.6,4) E4(-4.8,4) E5(-4,4) E6(-3.2,4) E7(-2.4,4) E8(-1.6,4) E9(-0.8,4) E10(0,4) E11(0.8,4) E12(1.6,4) E13(2.4,4) E14(3.2,4) E15(4,4) E16(4.8,4) E17(5.6,4) E18(6.4,4) E19(7.2,4) F1(-7.2,3.2) F2(-6.4,3.2) F3(-5.6,3.2) F4(-4.8,3.2) F5(-4,3.2) F6(-3.2,3.2) F7(-2.4,3.2) F8(-1.6,3.2) F9(-0.8,3.2) F10(0,3.2) F11(0.8,3.2) F12(1.6,3.2) F13(2.4,3.2) F14(3.2,3.2) F15(4,3.2) F16(4.8,3.2) F17(5.6,3.2) F18(6.4,3.2) F19(7.2,3.2) G1(-7.2,2.4) G2(-6.4,2.4) G3(-5.6,2.4) G4(-4.8,2.4) G5(-4,2.4) G6(-3.2,2.4) G7(-2.4,2.4) G8(-1.6,2.4) G9(-0.8,2.4) G10(0,2.4) G11(0.8,2.4) G12(1.6,2.4) G13(2.4,2.4) G14(3.2,2.4) G15(4,2.4) G16(4.8,2.4) G17(5.6,2.4) G18(6.4,2.4) G19(7.2,2.4) H1(-7.2,1.6) H2(-6.4,1.6) H3(-5.6,1.6) H4(-4.8,1.6) H5(-4,1.6) H6(-3.2,1.6) H7(-2.4,1.6) H8(-1.6,1.6) H9(-0.8,1.6) H10(0,1.6) H11(0.8,1.6) H12(1.6,1.6) H13(2.4,1.6) H14(3.2,1.6) H15(4,1.6) H16(4.8,1.6) H17(5.6,1.6) H18(6.4,1.6) H19(7.2,1.6) J1(-7.2,0.8) J2(-6.4,0.8) J3(-5.6,0.8) J4(-4.8,0.8) J5(-4,0.8) J6(-3.2,0.8) J7(-2.4,0.8) J8(-1.6,0.8) J9(-0.8,0.8) J10(0,0.8) J11(0.8,0.8) J12(1.6,0.8) J13(2.4,0.8) J14(3.2,0.8) J15(4,0.8) J16(4.8,0.8) J17(5.6,0.8) J18(6.4,0.8) J19(7.2,0.8) K1(-7.2,0) K2(-6.4,0) K3(-5.6,0) K4(-4.8,0) K5(-4,0) K6(-3.2,0) K7(-2.4,0) K8(-1.6,0) K9(-0.8,0) K10(0,0) K11(0.8,0) K12(1.6,0) K13(2.4,0) K14(3.2,0) K15(4,0) K16(4.8,0) K17(5.6,0) K18(6.4,0) K19(7.2,0) L1(-7.2,-0.8) L2(-6.4,-0.8) L3(-5.6,-0.8) L4(-4.8,-0.8) L5(-4,-0.8) L6(-3.2,-0.8) L7(-2.4,-0.8) L8(-1.6,-0.8) L9(-0.8,-0.8) L10(0,-0.8) L11(0.8,-0.8) L12(1.6,-0.8) L13(2.4,-0.8) L14(3.2,-0.8) L15(4,-0.8) L16(4.8,-0.8) L17(5.6,-0.8) L18(6.4,-0.8) L19(7.2,-0.8) M1(-7.2,-1.6) M2(-6.4,-1.6) M3(-5.6,-1.6) M4(-4.8,-1.6) M5(-4,-1.6) M6(-3.2,-1.6) M7(-2.4,-1.6) M8(-1.6,-1.6) M9(-0.8,-1.6) M10(0,-1.6) M11(0.8,-1.6) M12(1.6,-1.6) M13(2.4,-1.6) M14(3.2,-1.6) M15(4,-1.6) M16(4.8,-1.6) M17(5.6,-1.6) M18(6.4,-1.6) M19(7.2,-1.6) N1(-7.2,-2.4) N2(-6.4,-2.4) N3(-5.6,-2.4) N4(-4.8,-2.4) N5(-4,-2.4) N6(-3.2,-2.4) N7(-2.4,-2.4) N8(-1.6,-2.4) N9(-0.8,-2.4) N10(0,-2.4) N11(0.8,-2.4) N12(1.6,-2.4) N13(2.4,-2.4) N14(3.2,-2.4) N15(4,-2.4) N16(4.8,-2.4) N17(5.6,-2.4) N18(6.4,-2.4) N19(7.2,-2.4) P1(-7.2,-3.2) P2(-6.4,-3.2) P3(-5.6,-3.2) P4(-4.8,-3.2) P5(-4,-3.2) P6(-3.2,-3.2) P7(-2.4,-3.2) P8(-1.6,-3.2) P9(-0.8,-3.2) P10(0,-3.2) P11(0.8,-3.2) P12(1.6,-3.2) P13(2.4,-3.2) P14(3.2,-3.2) P15(4,-3.2) P16(4.8,-3.2) P17(5.6,-3.2) P18(6.4,-3.2) P19(7.2,-3.2) R1(-7.2,-4) R2(-6.4,-4) R3(-5.6,-4) R4(-4.8,-4) R5(-4,-4) R6(-3.2,-4) R7(-2.4,-4) R8(-1.6,-4) R9(-0.8,-4) R10(0,-4) R11(0.8,-4) R12(1.6,-4) R13(2.4,-4) R14(3.2,-4) R15(4,-4) R16(4.8,-4) R17(5.6,-4) R18(6.4,-4) R19(7.2,-4) T1(-7.2,-4.8) T2(-6.4,-4.8) T3(-5.6,-4.8) T4(-4.8,-4.8) T5(-4,-4.8) T6(-3.2,-4.8) T7(-2.4,-4.8) T8(-1.6,-4.8) T9(-0.8,-4.8) T10(0,-4.8) T11(0.8,-4.8) T12(1.6,-4.8) T13(2.4,-4.8) T14(3.2,-4.8) T15(4,-4.8) T16(4.8,-4.8) T17(5.6,-4.8) T18(6.4,-4.8) T19(7.2,-4.8) U1(-7.2,-5.6) U2(-6.4,-5.6) U3(-5.6,-5.6) U4(-4.8,-5.6) U5(-4,-5.6) U6(-3.2,-5.6) U7(-2.4,-5.6) U8(-1.6,-5.6) U9(-0.8,-5.6) U10(0,-5.6) U11(0.8,-5.6) U12(1.6,-5.6) U13(2.4,-5.6) U14(3.2,-5.6) U15(4,-5.6) U16(4.8,-5.6) U17(5.6,-5.6) U18(6.4,-5.6) U19(7.2,-5.6) V1(-7.2,-6.4) V2(-6.4,-6.4) V3(-5.6,-6.4) V4(-4.8,-6.4) V5(-4,-6.4) V6(-3.2,-6.4) V7(-2.4,-6.4) V8(-1.6,-6.4) V9(-0.8,-6.4) V10(0,-6.4) V11(0.8,-6.4) V12(1.6,-6.4) V13(2.4,-6.4) V14(3.2,-6.4) V15(4,-6.4) V16(4.8,-6.4) V17(5.6,-6.4) V18(6.4,-6.4) V19(7.2,-6.4) W1(-7.2,-7.2) W2(-6.4,-7.2) W3(-5.6,-7.2) W4(-4.8,-7.2) W5(-4,-7.2) W6(-3.2,-7.2) W7(-2.4,-7.2) W8(-1.6,-7.2) W9(-0.8,-7.2) W10(0,-7.2) W11(0.8,-7.2) W12(1.6,-7.2) W13(2.4,-7.2) W14(3.2,-7.2) W15(4,-7.2) W16(4.8,-7.2) W17(5.6,-7.2) W18(6.4,-7.2) W19(7.2,-7.2)
BGA_63P_31_512X413_C14_EINF
  round 2.261 hole 2.261 unplated: (-8.382,-12.344) (-8.382,10.008) (8.382,-12.344) (8.382,10.008)
  round 1.295 hole 1.295 unplated: (-7.303,-2.565) (7.303,2.565)
  round 0.457 smd: A1(-4.4,-3.6) A2(-4.4,-2.8) A9(-4.4,2.8) A10(-4.4,3.6) B1(-3.6,-3.6) B9(-3.6,2.8) B10(-3.6,3.6) C3(-2.8,-2) C4(-2.8,-1.2) C5(-2.8,-0.4) C6(-2.8,0.4) C7(-2.8,1.2) C8(-2.8,2) D3(-2,-2) D4(-2,-1.2) D5(-2,-0.4) D6(-2,0.4) D7(-2,1.2) D8(-2,2) E3(-1.2,-2) E4(-1.2,-1.2) E5(-1.2,-0.4) E6(-1.2,0.4) E7(-1.2,1.2) E8(-1.2,2) F3(-0.4,-2) F4(-0.4,-1.2) F5(-0.4,-0.4) F6(-0.4,0.4) F7(-0.4,1.2) F8(-0.4,2) G3(0.4,-2) G4(0.4,-1.2) G5(0.4,-0.4) G6(0.4,0.4) G7(0.4,1.2) G8(0.4,2) H3(1.2,-2) H4(1.2,-1.2) H5(1.2,-0.4) H6(1.2,0.4) H7(1.2,1.2) H8(1.2,2) J3(2,-2) J4(2,-1.2) J5(2,-0.4) J6(2,0.4) J7(2,1.2) J8(2,2) K3(2.8,-2) K4(2.8,-1.2) K5(2.8,-0.4) K6(2.8,0.4) K7(2.8,1.2) K8(2.8,2) L1(3.6,-3.6) L2(3.6,-2.8) L9(3.6,2.8) L10(3.6,3.6) M1(4.4,-3.6) M2(4.4,-2.8) M9(4.4,2.8) M10(4.4,3.6)
C0402
  oval 0.711x0.381 smd: 1(0,0.45) 2(0,-0.45)
C0603
  oval 1.016x0.813 smd: 1(0,0.826) 2(0,-0.826)
C0805
  oval 1.778x0.889 smd: 1(0,-1.016) 2(0,1.016)
C1206-1
  custom 0.349x0.349 smd: 1(-1.15,0) 2(1.15,0)
C_2P_114_138X118
  rect 1.194x2.311 smd: 1(-1.448,0) 2(1.448,0)
CC0201_IPC7351_EINF
  custom 0.089x0.089 smd: 1(-0.33,0) 2(0.33,0)
CC1210
  rect 1.397x2.794 smd: 1(-1.55,0) 2(1.55,0)
CT7343
  rect 2.591x2.413 smd: 1(-3.2,0) 2(3.2,0)
CUI_PJ-044BH
  rect 4.1x1.6 hole 3.5x1: 1(0,0)
  rect 3.6x1.6 hole 3x1: 2(0,-6.2)
  rect 3.1x1.6 hole 2.5x1: 3(3.5,-5.2)
DBV-20X60-5
  rect 0.508x1.524 smd: 1(-0.95,-1.499) 2(0,-1.499) 3(0.95,-1.499) 4(0.95,1.499) 5(-0.95,1.499)
DFN50P350X135X55-14N
  rect 0.3x0.4 smd: 1(-1.5,-0.525) 2(-1,-0.525) 3(-0.5,-0.525) 4(0,-0.525) 5(0.5,-0.525) 6(1,-0.525) 7(1.5,-0.525) 8(1.5,0.525) 9(1,0.525) 10(0.5,0.525) 11(0,0.525) 12(-0.5,0.525) 13(-1,0.525) 14(-1.5,0.525)
DIO_DO214AA_SMB
  rect 2.286x2.591 smd: 1(-1.968,0) 2(1.968,0)
DIODE_2P_146_106X61_ANODE2
  oval 0.686x1.016 smd: 1(0,-1.852) 2(0,1.852)
DIODE_2P_158_197X110
  rect 1.981x1.702 smd: 1(-2.196,0) 2(2.196,0)
DSBGA50P_0P9X0P9_4
  round 0.203 smd: A1(-0.25,0.25) A2(0.25,0.25) B1(-0.25,-0.25) B2(0.25,-0.25)
FIDUCIAL
  round 1.016 smd: 1(0,0)
FIL_NFM21PC
  rect 0.61x0.787 smd: 1(-1,0) 3(1,0)
  rect 0.66x0.61 smd: 2(0,-0.625) 4(0,0.625)
GF-AMC-B
  rect 0.483x0.965 smd: (-30.749,1.066) (-29.999,1.066) (-29.249,1.066) (-28.499,1.067) (-28.499,1.066) (-27.749,1.067) (-27.748,1.066) (-26.249,1.066) (-19.5,1.067) (-12.748,1.069) (-1.5,1.069) (9.749,1.068) (21.001,1.068)
  rect 0.483x2.007 smd: (-30.001,0.548) (30,0.546)
  rect 0.483x1.702 smd: (-26.249,0.699) (-25.499,0.699) (-24,0.699) (-23.999,0.699) (-23.249,0.699) (-23.248,0.699) (-21.748,0.699) (-21.748,0.699) (-21,0.699) (-21,0.699) (-19.501,0.699) (-18.749,0.699) (-17.248,0.699) (-17.248,0.699) (-16.5,0.699) (-16.5,0.699) (-15,0.699) (-15,0.699) (-14.248,0.699) (-14.248,0.699) (-12.748,0.698) (-12,0.698) (-10.5,0.699) (-10.5,0.699) (-9.752,0.699) (-9.752,0.699) (-8.248,0.699) (-8.248,0.699) (-7.5,0.699) (-7.5,0.699) (-6,0.699) (-6,0.699) (-5.252,0.699) (-5.252,0.699) (-3.752,0.699) (-3.752,0.699) (-3,0.699) (-3,0.699) (-1.5,0.699) (-0.752,0.699) (0.748,0.699) (0.749,0.699) (1.5,0.699) (1.501,0.699) (3.001,0.699) (3.001,0.699) (3.749,0.699) (3.749,0.699) (5.249,0.699) (5.249,0.699) (6.001,0.699) (6.001,0.699) (7.501,0.699) (7.501,0.699) (8.249,0.699) (8.249,0.699) (9.749,0.698) (10.501,0.698) (12.001,0.699) (12.001,0.699) (12.749,0.699) (12.749,0.699) (14.249,0.699) (14.249,0.699) (15.001,0.699) (15.001,0.699) (16.501,0.699) (16.501,0.699) (17.249,0.699) (17.249,0.699) (18.749,0.699) (18.749,0.699) (19.501,0.699) (19.501,0.699) (21.001,0.699) (21.75,0.699) (23.249,0.699) (23.249,0.699) (24.001,0.699) (24.001,0.699) (25.502,0.699) (25.502,0.699) (26.25,0.699) (26.25,0.699) (27.75,0.699) (27.75,0.699) (28.502,0.699) (28.502,0.699) (30,0.699) (30.75,0.699)
  rect 0.483x4.191 smd: 1(-31.5,-0.546) 2(-30.75,-0.546) 4(-29.25,-0.546) 7(-27,-0.546) 9(-25.5,-0.546) 10(-24.75,-0.546) 13(-22.5,-0.546) 16(-20.25,-0.546) 18(-18.75,-0.546) 19(-18,-0.546) 22(-15.75,-0.546) 25(-13.5,-0.546) 27(-12,-0.546) 28(-11.25,-0.546) 31(-9,-0.546) 34(-6.75,-0.546) 37(-4.5,-0.546) 40(-2.25,-0.546) 42(-0.75,-0.546) 43(0,-0.546) 46(2.25,-0.546) 49(4.5,-0.546) 52(6.75,-0.546) 55(9,-0.546) 57(10.5,-0.546) 58(11.25,-0.546) 61(13.5,-0.546) 64(15.75,-0.546) 67(18,-0.546) 70(20.25,-0.546) 72(21.75,-0.546) 73(22.5,-0.546) 76(24.75,-0.546) 79(27,-0.546) 82(29.25,-0.546) 84(30.75,-0.546) 85(31.5,-0.546) 86(31.5,-0.546) 89(29.25,-0.546) 92(27,-0.546) 95(24.75,-0.546) 98(22.5,-0.546) 101(20.25,-0.546) 104(18,-0.546) 107(15.75,-0.546) 110(13.5,-0.546) 113(11.25,-0.546) 116(9,-0.546) 119(6.75,-0.546) 122(4.5,-0.546) 125(2.25,-0.546) 128(0,-0.546) 131(-2.25,-0.546) 134(-4.5,-0.546) 137(-6.75,-0.546) 140(-9,-0.546) 143(-11.25,-0.546) 146(-13.5,-0.546) 149(-15.75,-0.546) 152(-18,-0.546) 155(-20.25,-0.546) 158(-22.5,-0.546) 161(-24.75,-0.546) 164(-27,-0.546) 170(-31.5,-0.546)
  rect 0.483x1.981 smd: 3(-29.999,-1.649) 83(30,-1.651)
  rect 0.483x3.023 smd: 5(-28.499,-1.131) 6(-27.749,-1.131) 8(-26.249,-1.131) 17(-19.502,-1.131) 26(-12.748,-1.129) 41(-1.5,-1.129) 56(9.749,-1.129) 71(21.001,-1.129) 165(-27.749,-1.131) 166(-28.499,-1.131) 167(-29.249,-1.131) 168(-29.999,-1.131) 169(-30.749,-1.131)
  rect 0.483x2.286 smd: 11(-24,-1.499) 12(-23.249,-1.499) 14(-21.748,-1.498) 15(-21,-1.498) 20(-17.248,-1.498) 21(-16.5,-1.498) 23(-15,-1.499) 24(-14.248,-1.499) 29(-10.5,-1.499) 30(-9.752,-1.499) 32(-8.248,-1.499) 33(-7.5,-1.499) 35(-6,-1.499) 36(-5.252,-1.499) 38(-3.752,-1.499) 39(-3,-1.499) 44(0.749,-1.499) 45(1.501,-1.499) 47(3.001,-1.499) 48(3.749,-1.499) 50(5.249,-1.499) 51(6.001,-1.499) 53(7.501,-1.499) 54(8.249,-1.499) 59(12.001,-1.499) 60(12.749,-1.499) 62(14.249,-1.499) 63(15.001,-1.499) 65(16.501,-1.499) 66(17.249,-1.499) 68(18.749,-1.499) 69(19.501,-1.499) 74(23.249,-1.499) 75(24.001,-1.499) 77(25.502,-1.499) 78(26.25,-1.499) 80(27.75,-1.499) 81(28.502,-1.499) 87(30.75,-1.499) 88(30,-1.499) 90(28.5,-1.499) 91(27.75,-1.499) 93(26.25,-1.499) 94(25.5,-1.499) 96(24,-1.499) 97(23.25,-1.499) 99(21.75,-1.499) 100(21,-1.499) 102(19.499,-1.499) 103(18.75,-1.499) 105(17.251,-1.498) 106(16.5,-1.498) 108(15.001,-1.499) 109(14.25,-1.499) 111(12.75,-1.499) 112(12,-1.499) 114(10.501,-1.499) 115(9.75,-1.499) 117(8.249,-1.498) 118(7.5,-1.498) 120(5.999,-1.499) 121(5.249,-1.499) 123(3.75,-1.499) 124(2.999,-1.499) 126(1.5,-1.499) 127(0.749,-1.499) 129(-0.752,-1.499) 130(-1.501,-1.499) 132(-3.002,-1.499) 133(-3.751,-1.499) 135(-5.25,-1.499) 136(-5.999,-1.499) 138(-7.5,-1.499) 139(-8.249,-1.499) 141(-9.75,-1.499) 142(-10.499,-1.499) 144(-12,-1.499) 145(-12.749,-1.499) 147(-14.25,-1.499) 148(-14.999,-1.499) 150(-16.499,-1.499) 151(-17.249,-1.499) 153(-18.748,-1.499) 154(-19.499,-1.499) 156(-20.999,-1.499) 157(-21.749,-1.499) 159(-23.249,-1.499) 160(-23.999,-1.499) 162(-25.499,-1.499) 163(-26.249,-1.499)
H27P35-MTH
  round 3.505 hole 2.692: 1(0,0)
H35-NPTH
  round 3.505 hole 3.505 unplated: (0,0)
H107X17-NPTH
  oval 10.693x1.702 hole 10.693x1.702 unplated: (0,0)
HD_5X1P_100_D
  rect 1.549x1.549 hole 1.143: 1(-5.08,0)
  round 1.549 hole 1.143: 2(-2.54,0) 3(0,0) 4(2.54,0) 5(5.08,0)
IND1008
  rect 0.991x1.499 smd: 1(-1.25,0) 2(1.25,0)
IND_IHLP3232DZERR47M01
  rect 2.413x5.334 smd: 1(-3.619,0) 2(3.619,0)
IND_VLC5045T-100M
  rect 4.902x2.108 smd: 1(0,-1.7) 2(0,1.7)
IND_VLCF5020T
  rect 4.902x2.108 smd: 1(0,-1.7) 2(0,1.7)
IND_XAL5030-222MEB
  rect 1.18x4.4 smd: 1(-1.655,0) 2(1.655,0)
INDC1206
  rect 1.397x1.905 smd: 1(-1.55,0) 2(1.55,0)
KYCON_KMMXAB10SMT4SB30
  rect 0.4x1.35 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(2.6,0) 6(6.7,0) 7(7.35,0) 8(8,0) 9(8.65,0) 10(9.3,0)
  rect 2.3x1.9 smd: SH1(-2.45,-2.675) SH4(5.05,-2.675) SH6(10.4,-2.675)
  rect 1.9x1.9 smd: SH2(0.1,-2.675) SH3(2.5,-2.675)
  rect 1.8x1.9 smd: SH5(7.8,-2.675)
L0402
  oval 0.381x0.711 smd: 1(-0.45,0) 2(0.45,0)
L0603
  oval 1.016x0.889 smd: 1(0,0.826) 2(0,-0.826)
L0805
  oval 1.778x1.016 smd: 1(0,-1.016) 2(0,1.016)
L1206
  rect 1.397x1.905 smd: 1(-1.55,0) 2(1.55,0)
L_3P_70_63X35
  rect 0.889x0.889 smd: 1(-0.89,0) 3(0.89,0)
  rect 0.406x1.702 smd: 2(0,0)
LCD_17P_NHD-C12832A1Z
  round 1.067 hole 1.067 unplated: (-20.1,11.55) (-20.1,-11.55) (20.1,11.55) (20.1,-11.55)
  rect 1.219x1.219 hole 0.813: 1(-12,-11.55)
  round 1.219 hole 0.813: 2(-10.5,-11.55) 3(-9,-11.55) 4(-7.5,-11.55) 5(-6,-11.55) 6(-4.5,-11.55) 7(-3,-11.55) 8(-1.5,-11.55) 9(0,-11.55) 10(1.5,-11.55) 11(3,-11.55) 12(4.5,-11.55) 13(6,-11.55) 14(7.5,-11.55) 15(9,-11.55) 16(10.5,-11.55) 17(12,-11.55)
  oval 2.921x1.981 hole 1.905x0.965: A(-17.3,-9.6) K(17.3,-9.6)
LED603-35X45-REV
  oval 0.889x1.143 smd: 1(0.762,0) 2(-0.762,0)
LED_2P_KPA-1606EC
  rect 0.889x0.61 smd: 1(-0.8,0) 2(0.8,0)
LED_2P_KPA-1606QBC-D
  rect 0.889x0.61 smd: 1(-0.8,0) 2(0.8,0)
LED_2P_KPBA-3010ESGC
  rect 1.143x1.016 smd: 1(-1.55,-0.064) 3(1.55,-0.064)
  rect 1.016x1.016 smd: 2(0,0.65)
LED_0603
  rect 0.813x0.813 smd: 1(-0.75,0) 2(0.75,0)
LED_LTST-C171
  rect 1.092x1.245 smd: 1(-1.25,0) 2(1.25,0)
LED_SML-LX0402
  rect 0.711x0.508 smd: 1(-0.55,0) 2(0.55,0)
MOL22-23-2041
  rect 1.448x1.448 hole 1.016: 1(0,0)
  round 1.448 hole 1.016: 2(2.54,0) 3(5.08,0) 4(7.62,0)
MOL54819-0519
  oval 1.092x1.651 hole 0.711: 1(0,0) 2(0.8,-1.2) 3(1.6,0) 4(2.4,-1.2) 5(3.2,0)
  oval 1.702x2.692 hole 0.711x1.905: 6(-2.05,-5.05) 7(5.25,-5.05)
MOL67800-5005
  rect 0.889x2.388 smd: 1(0,0) 2(-1.27,0) 3(-2.54,0) 4(-3.81,0) 5(-5.08,0) 6(-6.35,0) 7(-7.62,0)
  round 1.778 hole 1.346: M1(2.46,-1.1) M2(-10.37,-0.1)
OSC_CB3LV_3C
  rect 1.803x2.083 smd: 1(-2.54,-2.1) 2(2.54,-2.1) 3(2.54,2.1) 4(-2.54,2.1)
OSCCC200X250X70-4N
  rect 1.05x0.95 smd: 1(-0.925,-0.725) 2(0.925,-0.725) 3(0.925,0.725) 4(-0.925,0.725)
POWERMODULE_2P_5223957-3
  round 3.175 hole 3.175 unplated: (0,-15)
  round 8.992 hole 3.175: 1(0,0)
PTC_RUEF300
  rect 1.499x1.499 hole 1.067: 1(0,0)
  round 1.499 hole 1.067: 2(4.24,-2.2)
PVQFN50P400X400_24_PWP_EINF
  custom 0.07x0.07 smd: 1(-1.975,1.25) 2(-1.975,0.75) 3(-1.975,0.25) 4(-1.975,-0.25) 5(-1.975,-0.75) 6(-1.975,-1.25) 7(-1.25,-1.975) 8(-0.75,-1.975) 9(-0.25,-1.975) 10(0.25,-1.975) 11(0.75,-1.975) 12(1.25,-1.975) 13(1.975,-1.25) 14(1.975,-0.75) 15(1.975,-0.25) 16(1.975,0.25) 17(1.975,0.75) 18(1.975,1.25) 19(1.25,1.975) 20(0.75,1.975) 21(0.25,1.975) 22(-0.25,1.975) 23(-0.75,1.975) 24(-1.25,1.975)
  rect 2.692x2.692 smd: 25(0,0)
PVQFN50P550X350X100-25N_EINF
  custom 0.07x0.07 smd: 1(-2.725,-0.75) 2(-2.25,-1.725) 3(-1.75,-1.725) 4(-1.25,-1.725) 5(-0.75,-1.725) 6(-0.25,-1.725) 7(0.25,-1.725) 8(0.75,-1.725) 9(1.25,-1.725) 10(1.75,-1.725) 11(2.25,-1.725) 12(2.725,-0.75) 13(2.725,0.75) 14(2.25,1.725) 15(1.75,1.725) 16(1.25,1.725) 17(0.75,1.725) 18(0.25,1.725) 19(-0.25,1.725) 20(-0.75,1.725) 21(-1.25,1.725) 22(-1.75,1.725) 23(-2.25,1.725) 24(-2.725,0.75)
  custom 0.512x0.512 smd: 25(0,0)
QFN10P_20_118X118_TP94X65V5
  oval 0.279x0.991 smd: 1(-1,-1.5) 2(-0.5,-1.5) 3(0,-1.5) 4(0.5,-1.5) 5(1,-1.5) 6(1,1.5) 7(0.5,1.5) 8(0,1.5) 9(-0.5,1.5) 10(-1,1.5)
  custom 0.406x0.406 smd: 11(0,0)
  round 0.559 hole 0.305: 12(-0.75,-0.5) 13(0.75,-0.5) 14(-0.75,0.5) 15(0.75,0.5) 16(0,0)
QFN40P700X700X90-57N_EINF
  oval 0.85x0.2 smd: 1(-3.45,2.6) 2(-3.45,2.2) 3(-3.45,1.8) 4(-3.45,1.4) 5(-3.45,1) 6(-3.45,0.6) 7(-3.45,0.2) 8(-3.45,-0.2) 9(-3.45,-0.6) 10(-3.45,-1) 11(-3.45,-1.4) 12(-3.45,-1.8) 13(-3.45,-2.2) 14(-3.45,-2.6) 29(3.45,-2.6) 30(3.45,-2.2) 31(3.45,-1.8) 32(3.45,-1.4) 33(3.45,-1) 34(3.45,-0.6) 35(3.45,-0.2) 36(3.45,0.2) 37(3.45,0.6) 38(3.45,1) 39(3.45,1.4) 40(3.45,1.8) 41(3.45,2.2) 42(3.45,2.6)
  oval 0.2x0.85 smd: 15(-2.6,-3.45) 16(-2.2,-3.45) 17(-1.8,-3.45) 18(-1.4,-3.45) 19(-1,-3.45) 20(-0.6,-3.45) 21(-0.2,-3.45) 22(0.2,-3.45) 23(0.6,-3.45) 24(1,-3.45) 25(1.4,-3.45) 26(1.8,-3.45) 27(2.2,-3.45) 28(2.6,-3.45) 43(2.6,3.45) 44(2.2,3.45) 45(1.8,3.45) 46(1.4,3.45) 47(1,3.45) 48(0.6,3.45) 49(0.2,3.45) 50(-0.2,3.45) 51(-0.6,3.45) 52(-1,3.45) 53(-1.4,3.45) 54(-1.8,3.45) 55(-2.2,3.45) 56(-2.6,3.45)
  rect 3.7x4 smd: 57(0,0)
QFN50P300X300X80-17N_A_EINF
  custom 0.07x0.07 smd: 1(-1.475,0.75) 2(-1.475,0.25) 3(-1.475,-0.25) 4(-1.475,-0.75) 5(-0.75,-1.475) 6(-0.25,-1.475) 7(0.25,-1.475) 8(0.75,-1.475) 9(1.475,-0.75) 10(1.475,-0.25) 11(1.475,0.25) 12(1.475,0.75) 13(0.75,1.475) 14(0.25,1.475) 15(-0.25,1.475) 16(-0.75,1.475)
  rect 1.7x1.7 smd: 17(0,0)
QFN50P400X350_16_PWP_TI
  custom 0.07x0.07 smd: 1(-1.975,-0.75) 2(-1.25,-1.725) 3(-0.75,-1.725) 4(-0.25,-1.725) 5(0.25,-1.725) 6(0.75,-1.725) 7(1.25,-1.725) 8(1.975,-0.75) 9(1.975,0.75) 10(1.25,1.725) 11(0.75,1.725) 12(0.25,1.725) 13(-0.25,1.725) 14(-0.75,1.725) 15(-1.25,1.725) 16(-1.975,0.75)
  rect 2.54x2.057 smd: 17(0,0)
QFN50P500X700X152-41N_EINF
  custom 0.07x0.07 smd: 1(-2.475,2.75) 2(-2.475,2.25) 3(-2.475,1.75) 4(-2.475,1.25) 5(-2.475,0.75) 6(-2.475,0.25) 7(-2.475,-0.25) 8(-2.475,-0.75) 9(-2.475,-1.25) 10(-2.475,-1.75) 11(-2.475,-2.25) 12(-2.475,-2.75) 13(-1.75,-3.475) 14(-1.25,-3.475) 15(-0.75,-3.475) 16(-0.25,-3.475) 17(0.25,-3.475) 18(0.75,-3.475) 19(1.25,-3.475) 20(1.75,-3.475) 21(2.475,-2.75) 22(2.475,-2.25) 23(2.475,-1.75) 24(2.475,-1.25) 25(2.475,-0.75) 26(2.475,-0.25) 27(2.475,0.25) 28(2.475,0.75) 29(2.475,1.25) 30(2.475,1.75) 31(2.475,2.25) 32(2.475,2.75) 33(1.75,3.475) 34(1.25,3.475) 35(0.75,3.475) 36(0.25,3.475) 37(-0.25,3.475) 38(-0.75,3.475) 39(-1.25,3.475) 40(-1.75,3.475)
  rect 3.3x5.3 smd: 41(0,0)
QFN50P700X700X100-49N_C_EINF
  oval 0.9x0.3 smd: 1(-3.45,2.75) 2(-3.45,2.25) 3(-3.45,1.75) 4(-3.45,1.25) 5(-3.45,0.75) 6(-3.45,0.25) 7(-3.45,-0.25) 8(-3.45,-0.75) 9(-3.45,-1.25) 10(-3.45,-1.75) 11(-3.45,-2.25) 12(-3.45,-2.75) 25(3.45,-2.75) 26(3.45,-2.25) 27(3.45,-1.75) 28(3.45,-1.25) 29(3.45,-0.75) 30(3.45,-0.25) 31(3.45,0.25) 32(3.45,0.75) 33(3.45,1.25) 34(3.45,1.75) 35(3.45,2.25) 36(3.45,2.75)
  oval 0.3x0.9 smd: 13(-2.75,-3.45) 14(-2.25,-3.45) 15(-1.75,-3.45) 16(-1.25,-3.45) 17(-0.75,-3.45) 18(-0.25,-3.45) 19(0.25,-3.45) 20(0.75,-3.45) 21(1.25,-3.45) 22(1.75,-3.45) 23(2.25,-3.45) 24(2.75,-3.45) 37(2.75,3.45) 38(2.25,3.45) 39(1.75,3.45) 40(1.25,3.45) 41(0.75,3.45) 42(0.25,3.45) 43(-0.25,3.45) 44(-0.75,3.45) 45(-1.25,3.45) 46(-1.75,3.45) 47(-2.25,3.45) 48(-2.75,3.45)
  rect 4.6x5.45 smd: 49(0,0)
QFN50P800X800X100-57N
  round 1 smd: (-4.759,-4.759) (4.759,4.759)
  oval 0.85x0.3 smd: 1(-3.95,3.25) 2(-3.95,2.75) 3(-3.95,2.25) 4(-3.95,1.75) 5(-3.95,1.25) 6(-3.95,0.75) 7(-3.95,0.25) 8(-3.95,-0.25) 9(-3.95,-0.75) 10(-3.95,-1.25) 11(-3.95,-1.75) 12(-3.95,-2.25) 13(-3.95,-2.75) 14(-3.95,-3.25) 29(3.95,-3.25) 30(3.95,-2.75) 31(3.95,-2.25) 32(3.95,-1.75) 33(3.95,-1.25) 34(3.95,-0.75) 35(3.95,-0.25) 36(3.95,0.25) 37(3.95,0.75) 38(3.95,1.25) 39(3.95,1.75) 40(3.95,2.25) 41(3.95,2.75) 42(3.95,3.25)
  oval 0.3x0.85 smd: 15(-3.25,-3.95) 16(-2.75,-3.95) 17(-2.25,-3.95) 18(-1.75,-3.95) 19(-1.25,-3.95) 20(-0.75,-3.95) 21(-0.25,-3.95) 22(0.25,-3.95) 23(0.75,-3.95) 24(1.25,-3.95) 25(1.75,-3.95) 26(2.25,-3.95) 27(2.75,-3.95) 28(3.25,-3.95) 43(3.25,3.95) 44(2.75,3.95) 45(2.25,3.95) 46(1.75,3.95) 47(1.25,3.95) 48(0.75,3.95) 49(0.25,3.95) 50(-0.25,3.95) 51(-0.75,3.95) 52(-1.25,3.95) 53(-1.75,3.95) 54(-2.25,3.95) 55(-2.75,3.95) 56(-3.25,3.95)
  rect 4.55x4.55 smd: 57(0,0)
QFN_8P_26_118X118
  oval 0.381x1.016 smd: 1(-0.975,-1.5) 2(-0.325,-1.5) 3(0.325,-1.5) 4(0.975,-1.5) 5(0.975,1.5) 6(0.325,1.5) 7(-0.325,1.5) 8(-0.975,1.5)
  custom 0.375x0.375 smd: 9(0,0)
QFN_14P_20_138X138_TP79
  oval 1.016x0.279 smd: 1(-1.75,-0.75) 7(1.75,-0.75) 8(1.75,0.75) 14(-1.75,0.75)
  oval 0.279x1.016 smd: 2(-1,-1.75) 3(-0.5,-1.75) 4(0,-1.75) 5(0.5,-1.75) 6(1,-1.75) 9(1,1.75) 10(0.5,1.75) 11(0,1.75) 12(-0.5,1.75) 13(-1,1.75)
  custom 0.508x0.508 smd: 15(0,0)
QFN_20P_20_177X138_TP
  oval 1.016x0.279 smd: 1(-2.25,-0.75) 10(2.25,-0.75) 11(2.25,0.75) 20(-2.25,0.75)
  oval 0.279x1.016 smd: 2(-1.75,-1.75) 3(-1.25,-1.75) 4(-0.75,-1.75) 5(-0.25,-1.75) 6(0.25,-1.75) 7(0.75,-1.75) 8(1.25,-1.75) 9(1.75,-1.75) 12(1.75,1.75) 13(1.25,1.75) 14(0.75,1.75) 15(0.25,1.75) 16(-0.25,1.75) 17(-0.75,1.75) 18(-1.25,1.75) 19(-1.75,1.75)
  rect 2.997x2.007 smd: 21(0,0)
  round 0.508 hole 0.254: 22(-1,-0.5) 23(-1,0.5) 24(0,-0.5) 25(0,0.5) 26(1,-0.5) 27(1,0.5)
QFN_48P_20_276X276_TP161V16
  oval 0.279x1.016 smd: 1(-2.75,-3.5) 2(-2.25,-3.5) 3(-1.75,-3.5) 4(-1.25,-3.5) 5(-0.75,-3.5) 6(-0.25,-3.5) 7(0.25,-3.5) 8(0.75,-3.5) 9(1.25,-3.5) 10(1.75,-3.5) 11(2.25,-3.5) 12(2.75,-3.5) 25(2.75,3.5) 26(2.25,3.5) 27(1.75,3.5) 28(1.25,3.5) 29(0.75,3.5) 30(0.25,3.5) 31(-0.25,3.5) 32(-0.75,3.5) 33(-1.25,3.5) 34(-1.75,3.5) 35(-2.25,3.5) 36(-2.75,3.5)
  oval 1.016x0.279 smd: 13(3.5,-2.75) 14(3.5,-2.25) 15(3.5,-1.75) 16(3.5,-1.25) 17(3.5,-0.75) 18(3.5,-0.25) 19(3.5,0.25) 20(3.5,0.75) 21(3.5,1.25) 22(3.5,1.75) 23(3.5,2.25) 24(3.5,2.75) 37(-3.5,2.75) 38(-3.5,2.25) 39(-3.5,1.75) 40(-3.5,1.25) 41(-3.5,0.75) 42(-3.5,0.25) 43(-3.5,-0.25) 44(-3.5,-0.75) 45(-3.5,-1.25) 46(-3.5,-1.75) 47(-3.5,-2.25) 48(-3.5,-2.75)
  rect 4.089x4.089 smd: 49(0,0)
  round 0.559 hole 0.305: 50(-1.499,-1.499) 51(-0.499,-1.499) 52(0.501,-1.499) 53(1.501,-1.499) 54(-1.499,-0.499) 55(-0.499,-0.499) 56(0.501,-0.499) 57(1.501,-0.499) 58(-1.499,0.501) 59(-0.499,0.501) 60(0.501,0.501) 61(1.501,0.501) 62(-1.499,1.501) 63(-0.499,1.501) 64(0.501,1.501) 65(1.501,1.501)
QFN_48P_20_276X276_TP202V25
  oval 0.279x0.991 smd: 1(-2.75,-3.5) 2(-2.25,-3.5) 3(-1.75,-3.5) 4(-1.25,-3.5) 5(-0.75,-3.5) 6(-0.25,-3.5) 7(0.25,-3.5) 8(0.75,-3.5) 9(1.25,-3.5) 10(1.75,-3.5) 11(2.25,-3.5) 12(2.75,-3.5) 25(2.75,3.5) 26(2.25,3.5) 27(1.75,3.5) 28(1.25,3.5) 29(0.75,3.5) 30(0.25,3.5) 31(-0.25,3.5) 32(-0.75,3.5) 33(-1.25,3.5) 34(-1.75,3.5) 35(-2.25,3.5) 36(-2.75,3.5)
  oval 0.991x0.279 smd: 13(3.5,-2.75) 14(3.5,-2.25) 15(3.5,-1.75) 16(3.5,-1.25) 17(3.5,-0.75) 18(3.5,-0.25) 19(3.5,0.25) 20(3.5,0.75) 21(3.5,1.25) 22(3.5,1.75) 23(3.5,2.25) 24(3.5,2.75) 37(-3.5,2.75) 38(-3.5,2.25) 39(-3.5,1.75) 40(-3.5,1.25) 41(-3.5,0.75) 42(-3.5,0.25) 43(-3.5,-0.25) 44(-3.5,-0.75) 45(-3.5,-1.25) 46(-3.5,-1.75) 47(-3.5,-2.25) 48(-3.5,-2.75)
  rect 5.131x5.131 smd: 49(0,0)
  round 0.559 hole 0.305: 50(-2,-2) 51(-1,-2) 52(0,-2) 53(1,-2) 54(2,-2) 55(-2,-1) 56(-1,-1) 57(0,-1) 58(1,-1) 59(2,-1) 60(-2,0) 61(-1,0) 62(0,0) 63(1,0) 64(2,0) 65(-2,1) 66(-1,1) 67(0,1) 68(1,1) 69(2,1) 70(-2,2) 71(-1,2) 72(0,2) 73(1,2) 74(2,2)
QFP_100P_20_630X630
  oval 0.279x1.372 smd: 1(-6,-7.822) 2(-5.5,-7.822) 3(-5,-7.822) 4(-4.5,-7.822) 5(-4,-7.822) 6(-3.5,-7.822) 7(-3,-7.822) 8(-2.5,-7.822) 9(-2,-7.822) 10(-1.5,-7.822) 11(-1,-7.822) 12(-0.5,-7.822) 13(0,-7.822) 14(0.5,-7.822) 15(1,-7.822) 16(1.5,-7.822) 17(2,-7.822) 18(2.5,-7.822) 19(3,-7.822) 20(3.5,-7.822) 21(4,-7.822) 22(4.5,-7.822) 23(5,-7.822) 24(5.5,-7.822) 25(6,-7.822) 51(6,7.822) 52(5.5,7.822) 53(5,7.822) 54(4.5,7.822) 55(4,7.822) 56(3.5,7.822) 57(3,7.822) 58(2.5,7.822) 59(2,7.822) 60(1.5,7.822) 61(1,7.822) 62(0.5,7.822) 63(0,7.822) 64(-0.5,7.822) 65(-1,7.822) 66(-1.5,7.822) 67(-2,7.822) 68(-2.5,7.822) 69(-3,7.822) 70(-3.5,7.822) 71(-4,7.822) 72(-4.5,7.822) 73(-5,7.822) 74(-5.5,7.822) 75(-6,7.822)
  oval 1.372x0.279 smd: 26(7.822,-6) 27(7.822,-5.5) 28(7.822,-5) 29(7.822,-4.5) 30(7.822,-4) 31(7.822,-3.5) 32(7.822,-3) 33(7.822,-2.5) 34(7.822,-2) 35(7.822,-1.5) 36(7.822,-1) 37(7.822,-0.5) 38(7.822,0) 39(7.822,0.5) 40(7.822,1) 41(7.822,1.5) 42(7.822,2) 43(7.822,2.5) 44(7.822,3) 45(7.822,3.5) 46(7.822,4) 47(7.822,4.5) 48(7.822,5) 49(7.822,5.5) 50(7.822,6) 76(-7.822,6) 77(-7.822,5.5) 78(-7.822,5) 79(-7.822,4.5) 80(-7.822,4) 81(-7.822,3.5) 82(-7.822,3) 83(-7.822,2.5) 84(-7.822,2) 85(-7.822,1.5) 86(-7.822,1) 87(-7.822,0.5) 88(-7.822,0) 89(-7.822,-0.5) 90(-7.822,-1) 91(-7.822,-1.5) 92(-7.822,-2) 93(-7.822,-2.5) 94(-7.822,-3) 95(-7.822,-3.5) 96(-7.822,-4) 97(-7.822,-4.5) 98(-7.822,-5) 99(-7.822,-5.5) 100(-7.822,-6)
R0402
  oval 0.381x0.711 smd: 1(-0.45,0) 2(0.45,0)
R0603
  oval 1.016x0.889 smd: 1(0,0.826) 2(0,-0.826)
R603-35X45
  oval 0.889x1.143 smd: 1(-0.762,0) 2(0.762,0)
R0805
  oval 1.651x1.016 smd: 1(0,-1.016) 2(0,1.016)
R1206
  oval 2.286x1.778 smd: 1(0,1.524) 2(0,-1.524)
RC0201_IPC7351_EINF
  custom 0.089x0.089 smd: 1(-0.33,0) 2(0.33,0)
RESN_EXBN8V_0402X4
  rect 0.356x0.61 smd: 1(-0.807,-0.544) 4(0.807,-0.544) 5(0.807,0.544) 8(-0.807,0.544)
  rect 0.254x0.61 smd: 2(-0.25,-0.544) 3(0.25,-0.544) 6(0.25,0.544) 7(-0.25,0.544)
SAMFTR-110-03-G-D-LC
  round 1.194 hole 1.194 unplated: (0.635,2.705) (10.795,2.705)
  rect 0.711x2.87 smd: 1(0,0) 2(0,5.41) 3(1.27,0) 4(1.27,5.41) 5(2.54,0) 6(2.54,5.41) 7(3.81,0) 8(3.81,5.41) 9(5.08,0) 10(5.08,5.41) 11(6.35,0) 12(6.35,5.41) 13(7.62,0) 14(7.62,5.41) 15(8.89,0) 16(8.89,5.41) 17(10.16,0) 18(10.16,5.41) 19(11.43,0) 20(11.43,5.41)
SAMTEC_TSW-106-23-T-S
  rect 1.62x1.62 hole 1.016: 1(0,0)
  round 1.62 hole 1.016: 2(2.54,0) 3(5.08,0) 4(7.62,0) 5(10.16,0) 6(12.7,0)
SAMTECH_FTSH-105-01-F-DV-K-P-TR
  rect 0.74x2.795 smd: 1(0,0) 2(0,4.064) 3(1.27,0) 4(1.27,4.064) 5(2.54,0) 6(2.54,4.064) 7(3.81,0) 8(3.81,4.064) 9(5.08,0) 10(5.08,4.064)
SAMTSW-102-22-T-S
  rect 1.448x1.448 hole 1.016: 1(0,0)
  round 1.448 hole 1.016: 2(-2.54,0)
SC70_5P
  oval 0.356x1.118 smd: 1(-0.65,-0.997) 2(0,-0.997) 3(0.65,-0.997) 4(0.65,0.997) 5(-0.65,0.997)
SC70_6P
  rect 0.406x1.092 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(0,0.95) 6(-0.65,0.95)
SC-70_5P
  oval 0.356x1.118 smd: 1(-0.65,-0.997) 2(0,-0.997) 3(0.65,-0.997) 4(0.65,0.997) 5(-0.65,0.997)
SKTBGA_SS1089-RHFB-BGA080
  round 1 hole 2.35 unplated: (-18.415,18.415) (-18.415,-18.415) (18.415,18.415) (18.415,-18.415)
  round 0.5 hole 0.66 unplated: (-16.385,-16.385) (16.385,16.385)
  round 0.47 smd: A1(-12.8,12.8) A2(-12,12.8) A3(-11.2,12.8) A4(-10.4,12.8) A5(-9.6,12.8) A6(-8.8,12.8) A7(-8,12.8) A8(-7.2,12.8) A9(-6.4,12.8) A10(-5.6,12.8) A11(-4.8,12.8) A12(-4,12.8) A13(-3.2,12.8) A14(-2.4,12.8) A15(-1.6,12.8) A16(-0.8,12.8) A17(0,12.8) A18(0.8,12.8) A19(1.6,12.8) A20(2.4,12.8) A21(3.2,12.8) A22(4,12.8) A23(4.8,12.8) A24(5.6,12.8) A25(6.4,12.8) A26(7.2,12.8) A27(8,12.8) A28(8.8,12.8) A29(9.6,12.8) A30(10.4,12.8) A31(11.2,12.8) A32(12,12.8) A33(12.8,12.8) AA1(-12.8,-3.2) AA2(-12,-3.2) AA3(-11.2,-3.2) AA4(-10.4,-3.2) AA5(-9.6,-3.2) AA6(-8.8,-3.2) AA7(-8,-3.2) AA8(-7.2,-3.2) AA9(-6.4,-3.2) AA10(-5.6,-3.2) AA11(-4.8,-3.2) AA12(-4,-3.2) AA13(-3.2,-3.2) AA14(-2.4,-3.2) AA15(-1.6,-3.2) AA16(-0.8,-3.2) AA17(0,-3.2) AA18(0.8,-3.2) AA19(1.6,-3.2) AA20(2.4,-3.2) AA21(3.2,-3.2) AA22(4,-3.2) AA23(4.8,-3.2) AA24(5.6,-3.2) AA25(6.4,-3.2) AA26(7.2,-3.2) AA27(8,-3.2) AA28(8.8,-3.2) AA29(9.6,-3.2) AA30(10.4,-3.2) AA31(11.2,-3.2) AA32(12,-3.2) AA33(12.8,-3.2) AB1(-12.8,-4) AB2(-12,-4) AB3(-11.2,-4) AB4(-10.4,-4) AB5(-9.6,-4) AB6(-8.8,-4) AB7(-8,-4) AB8(-7.2,-4) AB9(-6.4,-4) AB10(-5.6,-4) AB11(-4.8,-4) AB12(-4,-4) AB13(-3.2,-4) AB14(-2.4,-4) AB15(-1.6,-4) AB16(-0.8,-4) AB17(0,-4) AB18(0.8,-4) AB19(1.6,-4) AB20(2.4,-4) AB21(3.2,-4) AB22(4,-4) AB23(4.8,-4) AB24(5.6,-4) AB25(6.4,-4) AB26(7.2,-4) AB27(8,-4) AB28(8.8,-4) AB29(9.6,-4) AB30(10.4,-4) AB31(11.2,-4) AB32(12,-4) AB33(12.8,-4) AC1(-12.8,-4.8) AC2(-12,-4.8) AC3(-11.2,-4.8) AC4(-10.4,-4.8) AC5(-9.6,-4.8) AC6(-8.8,-4.8) AC7(-8,-4.8) AC8(-7.2,-4.8) AC9(-6.4,-4.8) AC10(-5.6,-4.8) AC11(-4.8,-4.8) AC12(-4,-4.8) AC13(-3.2,-4.8) AC14(-2.4,-4.8) AC15(-1.6,-4.8) AC16(-0.8,-4.8) AC17(0,-4.8) AC18(0.8,-4.8) AC19(1.6,-4.8) AC20(2.4,-4.8) AC21(3.2,-4.8) AC22(4,-4.8) AC23(4.8,-4.8) AC24(5.6,-4.8) AC25(6.4,-4.8) AC26(7.2,-4.8) AC27(8,-4.8) AC28(8.8,-4.8) AC29(9.6,-4.8) AC30(10.4,-4.8) AC31(11.2,-4.8) AC32(12,-4.8) AC33(12.8,-4.8) AD1(-12.8,-5.6) AD2(-12,-5.6) AD3(-11.2,-5.6) AD4(-10.4,-5.6) AD5(-9.6,-5.6) AD6(-8.8,-5.6) AD7(-8,-5.6) AD8(-7.2,-5.6) AD9(-6.4,-5.6) AD10(-5.6,-5.6) AD11(-4.8,-5.6) AD12(-4,-5.6) AD13(-3.2,-5.6) AD14(-2.4,-5.6) AD15(-1.6,-5.6) AD16(-0.8,-5.6) AD17(0,-5.6) AD18(0.8,-5.6) AD19(1.6,-5.6) AD20(2.4,-5.6) AD21(3.2,-5.6) AD22(4,-5.6) AD23(4.8,-5.6) AD24(5.6,-5.6) AD25(6.4,-5.6) AD26(7.2,-5.6) AD27(8,-5.6) AD28(8.8,-5.6) AD29(9.6,-5.6) AD30(10.4,-5.6) AD31(11.2,-5.6) AD32(12,-5.6) AD33(12.8,-5.6) AE1(-12.8,-6.4) AE2(-12,-6.4) AE3(-11.2,-6.4) AE4(-10.4,-6.4) AE5(-9.6,-6.4) AE6(-8.8,-6.4) AE7(-8,-6.4) AE8(-7.2,-6.4) AE9(-6.4,-6.4) AE10(-5.6,-6.4) AE11(-4.8,-6.4) AE12(-4,-6.4) AE13(-3.2,-6.4) AE14(-2.4,-6.4) AE15(-1.6,-6.4) AE16(-0.8,-6.4) AE17(0,-6.4) AE18(0.8,-6.4) AE19(1.6,-6.4) AE20(2.4,-6.4) AE21(3.2,-6.4) AE22(4,-6.4) AE23(4.8,-6.4) AE24(5.6,-6.4) AE25(6.4,-6.4) AE26(7.2,-6.4) AE27(8,-6.4) AE28(8.8,-6.4) AE29(9.6,-6.4) AE30(10.4,-6.4) AE31(11.2,-6.4) AE32(12,-6.4) AE33(12.8,-6.4) AF1(-12.8,-7.2) AF2(-12,-7.2) AF3(-11.2,-7.2) AF4(-10.4,-7.2) AF5(-9.6,-7.2) AF6(-8.8,-7.2) AF7(-8,-7.2) AF8(-7.2,-7.2) AF9(-6.4,-7.2) AF10(-5.6,-7.2) AF11(-4.8,-7.2) AF12(-4,-7.2) AF13(-3.2,-7.2) AF14(-2.4,-7.2) AF15(-1.6,-7.2) AF16(-0.8,-7.2) AF17(0,-7.2) AF18(0.8,-7.2) AF19(1.6,-7.2) AF20(2.4,-7.2) AF21(3.2,-7.2) AF22(4,-7.2) AF23(4.8,-7.2) AF24(5.6,-7.2) AF25(6.4,-7.2) AF26(7.2,-7.2) AF27(8,-7.2) AF28(8.8,-7.2) AF29(9.6,-7.2) AF30(10.4,-7.2) AF31(11.2,-7.2) AF32(12,-7.2) AF33(12.8,-7.2) AG1(-12.8,-8) AG2(-12,-8) AG3(-11.2,-8) AG4(-10.4,-8) AG5(-9.6,-8) AG6(-8.8,-8) AG7(-8,-8) AG8(-7.2,-8) AG9(-6.4,-8) AG10(-5.6,-8) AG11(-4.8,-8) AG12(-4,-8) AG13(-3.2,-8) AG14(-2.4,-8) AG15(-1.6,-8) AG16(-0.8,-8) AG17(0,-8) AG18(0.8,-8) AG19(1.6,-8) AG20(2.4,-8) AG21(3.2,-8) AG22(4,-8) AG23(4.8,-8) AG24(5.6,-8) AG25(6.4,-8) AG26(7.2,-8) AG27(8,-8) AG28(8.8,-8) AG29(9.6,-8) AG30(10.4,-8) AG31(11.2,-8) AG32(12,-8) AG33(12.8,-8) AH1(-12.8,-8.8) AH2(-12,-8.8) AH3(-11.2,-8.8) AH4(-10.4,-8.8) AH5(-9.6,-8.8) AH6(-8.8,-8.8) AH7(-8,-8.8) AH8(-7.2,-8.8) AH9(-6.4,-8.8) AH10(-5.6,-8.8) AH11(-4.8,-8.8) AH12(-4,-8.8) AH13(-3.2,-8.8) AH14(-2.4,-8.8) AH15(-1.6,-8.8) AH16(-0.8,-8.8) AH17(0,-8.8) AH18(0.8,-8.8) AH19(1.6,-8.8) AH20(2.4,-8.8) AH21(3.2,-8.8) AH22(4,-8.8) AH23(4.8,-8.8) AH24(5.6,-8.8) AH25(6.4,-8.8) AH26(7.2,-8.8) AH27(8,-8.8) AH28(8.8,-8.8) AH29(9.6,-8.8) AH30(10.4,-8.8) AH31(11.2,-8.8) AH32(12,-8.8) AH33(12.8,-8.8) AJ1(-12.8,-9.6) AJ2(-12,-9.6) AJ3(-11.2,-9.6) AJ4(-10.4,-9.6) AJ5(-9.6,-9.6) AJ6(-8.8,-9.6) AJ7(-8,-9.6) AJ8(-7.2,-9.6) AJ9(-6.4,-9.6) AJ10(-5.6,-9.6) AJ11(-4.8,-9.6) AJ12(-4,-9.6) AJ13(-3.2,-9.6) AJ14(-2.4,-9.6) AJ15(-1.6,-9.6) AJ16(-0.8,-9.6) AJ17(0,-9.6) AJ18(0.8,-9.6) AJ19(1.6,-9.6) AJ20(2.4,-9.6) AJ21(3.2,-9.6) AJ22(4,-9.6) AJ23(4.8,-9.6) AJ24(5.6,-9.6) AJ25(6.4,-9.6) AJ26(7.2,-9.6) AJ27(8,-9.6) AJ28(8.8,-9.6) AJ29(9.6,-9.6) AJ30(10.4,-9.6) AJ31(11.2,-9.6) AJ32(12,-9.6) AJ33(12.8,-9.6) AK1(-12.8,-10.4) AK2(-12,-10.4) AK3(-11.2,-10.4) AK4(-10.4,-10.4) AK5(-9.6,-10.4) AK6(-8.8,-10.4) AK7(-8,-10.4) AK8(-7.2,-10.4) AK9(-6.4,-10.4) AK10(-5.6,-10.4) AK11(-4.8,-10.4) AK12(-4,-10.4) AK13(-3.2,-10.4) AK14(-2.4,-10.4) AK15(-1.6,-10.4) AK16(-0.8,-10.4) AK17(0,-10.4) AK18(0.8,-10.4) AK19(1.6,-10.4) AK20(2.4,-10.4) AK21(3.2,-10.4) AK22(4,-10.4) AK23(4.8,-10.4) AK24(5.6,-10.4) AK25(6.4,-10.4) AK26(7.2,-10.4) AK27(8,-10.4) AK28(8.8,-10.4) AK29(9.6,-10.4) AK30(10.4,-10.4) AK31(11.2,-10.4) AK32(12,-10.4) AK33(12.8,-10.4) AL1(-12.8,-11.2) AL2(-12,-11.2) AL3(-11.2,-11.2) AL4(-10.4,-11.2) AL5(-9.6,-11.2) AL6(-8.8,-11.2) AL7(-8,-11.2) AL8(-7.2,-11.2) AL9(-6.4,-11.2) AL10(-5.6,-11.2) AL11(-4.8,-11.2) AL12(-4,-11.2) AL13(-3.2,-11.2) AL14(-2.4,-11.2) AL15(-1.6,-11.2) AL16(-0.8,-11.2) AL17(0,-11.2) AL18(0.8,-11.2) AL19(1.6,-11.2) AL20(2.4,-11.2) AL21(3.2,-11.2) AL22(4,-11.2) AL23(4.8,-11.2) AL24(5.6,-11.2) AL25(6.4,-11.2) AL26(7.2,-11.2) AL27(8,-11.2) AL28(8.8,-11.2) AL29(9.6,-11.2) AL30(10.4,-11.2) AL31(11.2,-11.2) AL32(12,-11.2) AL33(12.8,-11.2) AM1(-12.8,-12) AM2(-12,-12) AM3(-11.2,-12) AM4(-10.4,-12) AM5(-9.6,-12) AM6(-8.8,-12) AM7(-8,-12) AM8(-7.2,-12) AM9(-6.4,-12) AM10(-5.6,-12) AM11(-4.8,-12) AM12(-4,-12) AM13(-3.2,-12) AM14(-2.4,-12) AM15(-1.6,-12) AM16(-0.8,-12) AM17(0,-12) AM18(0.8,-12) AM19(1.6,-12) AM20(2.4,-12) AM21(3.2,-12) AM22(4,-12) AM23(4.8,-12) AM24(5.6,-12) AM25(6.4,-12) AM26(7.2,-12) AM27(8,-12) AM28(8.8,-12) AM29(9.6,-12) AM30(10.4,-12) AM31(11.2,-12) AM32(12,-12) AM33(12.8,-12) AN1(-12.8,-12.8) AN2(-12,-12.8) AN3(-11.2,-12.8) AN4(-10.4,-12.8) AN5(-9.6,-12.8) AN6(-8.8,-12.8) AN7(-8,-12.8) AN8(-7.2,-12.8) AN9(-6.4,-12.8) AN10(-5.6,-12.8) AN11(-4.8,-12.8) AN12(-4,-12.8) AN13(-3.2,-12.8) AN14(-2.4,-12.8) AN15(-1.6,-12.8) AN16(-0.8,-12.8) AN17(0,-12.8) AN18(0.8,-12.8) AN19(1.6,-12.8) AN20(2.4,-12.8) AN21(3.2,-12.8) AN22(4,-12.8) AN23(4.8,-12.8) AN24(5.6,-12.8) AN25(6.4,-12.8) AN26(7.2,-12.8) AN27(8,-12.8) AN28(8.8,-12.8) AN29(9.6,-12.8) AN30(10.4,-12.8) AN31(11.2,-12.8) AN32(12,-12.8) AN33(12.8,-12.8) B1(-12.8,12) B2(-12,12) B3(-11.2,12) B4(-10.4,12) B5(-9.6,12) B6(-8.8,12) B7(-8,12) B8(-7.2,12) B9(-6.4,12) B10(-5.6,12) B11(-4.8,12) B12(-4,12) B13(-3.2,12) B14(-2.4,12) B15(-1.6,12) B16(-0.8,12) B17(0,12) B18(0.8,12) B19(1.6,12) B20(2.4,12) B21(3.2,12) B22(4,12) B23(4.8,12) B24(5.6,12) B25(6.4,12) B26(7.2,12) B27(8,12) B28(8.8,12) B29(9.6,12) B30(10.4,12) B31(11.2,12) B32(12,12) B33(12.8,12) C1(-12.8,11.2) C2(-12,11.2) C3(-11.2,11.2) C4(-10.4,11.2) C5(-9.6,11.2) C6(-8.8,11.2) C7(-8,11.2) C8(-7.2,11.2) C9(-6.4,11.2) C10(-5.6,11.2) C11(-4.8,11.2) C12(-4,11.2) C13(-3.2,11.2) C14(-2.4,11.2) C15(-1.6,11.2) C16(-0.8,11.2) C17(0,11.2) C18(0.8,11.2) C19(1.6,11.2) C20(2.4,11.2) C21(3.2,11.2) C22(4,11.2) C23(4.8,11.2) C24(5.6,11.2) C25(6.4,11.2) C26(7.2,11.2) C27(8,11.2) C28(8.8,11.2) C29(9.6,11.2) C30(10.4,11.2) C31(11.2,11.2) C32(12,11.2) C33(12.8,11.2) D1(-12.8,10.4) D2(-12,10.4) D3(-11.2,10.4) D4(-10.4,10.4) D5(-9.6,10.4) D6(-8.8,10.4) D7(-8,10.4) D8(-7.2,10.4) D9(-6.4,10.4) D10(-5.6,10.4) D11(-4.8,10.4) D12(-4,10.4) D13(-3.2,10.4) D14(-2.4,10.4) D15(-1.6,10.4) D16(-0.8,10.4) D17(0,10.4) D18(0.8,10.4) D19(1.6,10.4) D20(2.4,10.4) D21(3.2,10.4) D22(4,10.4) D23(4.8,10.4) D24(5.6,10.4) D25(6.4,10.4) D26(7.2,10.4) D27(8,10.4) D28(8.8,10.4) D29(9.6,10.4) D30(10.4,10.4) D31(11.2,10.4) D32(12,10.4) D33(12.8,10.4) E1(-12.8,9.6) E2(-12,9.6) E3(-11.2,9.6) E4(-10.4,9.6) E5(-9.6,9.6) E6(-8.8,9.6) E7(-8,9.6) E8(-7.2,9.6) E9(-6.4,9.6) E10(-5.6,9.6) E11(-4.8,9.6) E12(-4,9.6) E13(-3.2,9.6) E14(-2.4,9.6) E15(-1.6,9.6) E16(-0.8,9.6) E17(0,9.6) E18(0.8,9.6) E19(1.6,9.6) E20(2.4,9.6) E21(3.2,9.6) E22(4,9.6) E23(4.8,9.6) E24(5.6,9.6) E25(6.4,9.6) E26(7.2,9.6) E27(8,9.6) E28(8.8,9.6) E29(9.6,9.6) E30(10.4,9.6) E31(11.2,9.6) E32(12,9.6) E33(12.8,9.6) F1(-12.8,8.8) F2(-12,8.8) F3(-11.2,8.8) F4(-10.4,8.8) F5(-9.6,8.8) F6(-8.8,8.8) F7(-8,8.8) F8(-7.2,8.8) F9(-6.4,8.8) F10(-5.6,8.8) F11(-4.8,8.8) F12(-4,8.8) F13(-3.2,8.8) F14(-2.4,8.8) F15(-1.6,8.8) F16(-0.8,8.8) F17(0,8.8) F18(0.8,8.8) F19(1.6,8.8) F20(2.4,8.8) F21(3.2,8.8) F22(4,8.8) F23(4.8,8.8) F24(5.6,8.8) F25(6.4,8.8) F26(7.2,8.8) F27(8,8.8) F28(8.8,8.8) F29(9.6,8.8) F30(10.4,8.8) F31(11.2,8.8) F32(12,8.8) F33(12.8,8.8) G1(-12.8,8) G2(-12,8) G3(-11.2,8) G4(-10.4,8) G5(-9.6,8) G6(-8.8,8) G7(-8,8) G8(-7.2,8) G9(-6.4,8) G10(-5.6,8) G11(-4.8,8) G12(-4,8) G13(-3.2,8) G14(-2.4,8) G15(-1.6,8) G16(-0.8,8) G17(0,8) G18(0.8,8) G19(1.6,8) G20(2.4,8) G21(3.2,8) G22(4,8) G23(4.8,8) G24(5.6,8) G25(6.4,8) G26(7.2,8) G27(8,8) G28(8.8,8) G29(9.6,8) G30(10.4,8) G31(11.2,8) G32(12,8) G33(12.8,8) H1(-12.8,7.2) H2(-12,7.2) H3(-11.2,7.2) H4(-10.4,7.2) H5(-9.6,7.2) H6(-8.8,7.2) H7(-8,7.2) H8(-7.2,7.2) H9(-6.4,7.2) H10(-5.6,7.2) H11(-4.8,7.2) H12(-4,7.2) H13(-3.2,7.2) H14(-2.4,7.2) H15(-1.6,7.2) H16(-0.8,7.2) H17(0,7.2) H18(0.8,7.2) H19(1.6,7.2) H20(2.4,7.2) H21(3.2,7.2) H22(4,7.2) H23(4.8,7.2) H24(5.6,7.2) H25(6.4,7.2) H26(7.2,7.2) H27(8,7.2) H28(8.8,7.2) H29(9.6,7.2) H30(10.4,7.2) H31(11.2,7.2) H32(12,7.2) H33(12.8,7.2) J1(-12.8,6.4) J2(-12,6.4) J3(-11.2,6.4) J4(-10.4,6.4) J5(-9.6,6.4) J6(-8.8,6.4) J7(-8,6.4) J8(-7.2,6.4) J9(-6.4,6.4) J10(-5.6,6.4) J11(-4.8,6.4) J12(-4,6.4) J13(-3.2,6.4) J14(-2.4,6.4) J15(-1.6,6.4) J16(-0.8,6.4) J17(0,6.4) J18(0.8,6.4) J19(1.6,6.4) J20(2.4,6.4) J21(3.2,6.4) J22(4,6.4) J23(4.8,6.4) J24(5.6,6.4) J25(6.4,6.4) J26(7.2,6.4) J27(8,6.4) J28(8.8,6.4) J29(9.6,6.4) J30(10.4,6.4) J31(11.2,6.4) J32(12,6.4) J33(12.8,6.4) K1(-12.8,5.6) K2(-12,5.6) K3(-11.2,5.6) K4(-10.4,5.6) K5(-9.6,5.6) K6(-8.8,5.6) K7(-8,5.6) K8(-7.2,5.6) K9(-6.4,5.6) K10(-5.6,5.6) K11(-4.8,5.6) K12(-4,5.6) K13(-3.2,5.6) K14(-2.4,5.6) K15(-1.6,5.6) K16(-0.8,5.6) K17(0,5.6) K18(0.8,5.6) K19(1.6,5.6) K20(2.4,5.6) K21(3.2,5.6) K22(4,5.6) K23(4.8,5.6) K24(5.6,5.6) K25(6.4,5.6) K26(7.2,5.6) K27(8,5.6) K28(8.8,5.6) K29(9.6,5.6) K30(10.4,5.6) K31(11.2,5.6) K32(12,5.6) K33(12.8,5.6) L1(-12.8,4.8) L2(-12,4.8) L3(-11.2,4.8) L4(-10.4,4.8) L5(-9.6,4.8) L6(-8.8,4.8) L7(-8,4.8) L8(-7.2,4.8) L9(-6.4,4.8) L10(-5.6,4.8) L11(-4.8,4.8) L12(-4,4.8) L13(-3.2,4.8) L14(-2.4,4.8) L15(-1.6,4.8) L16(-0.8,4.8) L17(0,4.8) L18(0.8,4.8) L19(1.6,4.8) L20(2.4,4.8) L21(3.2,4.8) L22(4,4.8) L23(4.8,4.8) L24(5.6,4.8) L25(6.4,4.8) L26(7.2,4.8) L27(8,4.8) L28(8.8,4.8) L29(9.6,4.8) L30(10.4,4.8) L31(11.2,4.8) L32(12,4.8) L33(12.8,4.8) M1(-12.8,4) M2(-12,4) M3(-11.2,4) M4(-10.4,4) M5(-9.6,4) M6(-8.8,4) M7(-8,4) M8(-7.2,4) M9(-6.4,4) M10(-5.6,4) M11(-4.8,4) M12(-4,4) M13(-3.2,4) M14(-2.4,4) M15(-1.6,4) M16(-0.8,4) M17(0,4) M18(0.8,4) M19(1.6,4) M20(2.4,4) M21(3.2,4) M22(4,4) M23(4.8,4) M24(5.6,4) M25(6.4,4) M26(7.2,4) M27(8,4) M28(8.8,4) M29(9.6,4) M30(10.4,4) M31(11.2,4) M32(12,4) M33(12.8,4) N1(-12.8,3.2) N2(-12,3.2) N3(-11.2,3.2) N4(-10.4,3.2) N5(-9.6,3.2) N6(-8.8,3.2) N7(-8,3.2) N8(-7.2,3.2) N9(-6.4,3.2) N10(-5.6,3.2) N11(-4.8,3.2) N12(-4,3.2) N13(-3.2,3.2) N14(-2.4,3.2) N15(-1.6,3.2) N16(-0.8,3.2) N17(0,3.2) N18(0.8,3.2) N19(1.6,3.2) N20(2.4,3.2) N21(3.2,3.2) N22(4,3.2) N23(4.8,3.2) N24(5.6,3.2) N25(6.4,3.2) N26(7.2,3.2) N27(8,3.2) N28(8.8,3.2) N29(9.6,3.2) N30(10.4,3.2) N31(11.2,3.2) N32(12,3.2) N33(12.8,3.2) P1(-12.8,2.4) P2(-12,2.4) P3(-11.2,2.4) P4(-10.4,2.4) P5(-9.6,2.4) P6(-8.8,2.4) P7(-8,2.4) P8(-7.2,2.4) P9(-6.4,2.4) P10(-5.6,2.4) P11(-4.8,2.4) P12(-4,2.4) P13(-3.2,2.4) P14(-2.4,2.4) P15(-1.6,2.4) P16(-0.8,2.4) P17(0,2.4) P18(0.8,2.4) P19(1.6,2.4) P20(2.4,2.4) P21(3.2,2.4) P22(4,2.4) P23(4.8,2.4) P24(5.6,2.4) P25(6.4,2.4) P26(7.2,2.4) P27(8,2.4) P28(8.8,2.4) P29(9.6,2.4) P30(10.4,2.4) P31(11.2,2.4) P32(12,2.4) P33(12.8,2.4) R1(-12.8,1.6) R2(-12,1.6) R3(-11.2,1.6) R4(-10.4,1.6) R5(-9.6,1.6) R6(-8.8,1.6) R7(-8,1.6) R8(-7.2,1.6) R9(-6.4,1.6) R10(-5.6,1.6) R11(-4.8,1.6) R12(-4,1.6) R13(-3.2,1.6) R14(-2.4,1.6) R15(-1.6,1.6) R16(-0.8,1.6) R17(0,1.6) R18(0.8,1.6) R19(1.6,1.6) R20(2.4,1.6) R21(3.2,1.6) R22(4,1.6) R23(4.8,1.6) R24(5.6,1.6) R25(6.4,1.6) R26(7.2,1.6) R27(8,1.6) R28(8.8,1.6) R29(9.6,1.6) R30(10.4,1.6) R31(11.2,1.6) R32(12,1.6) R33(12.8,1.6) T1(-12.8,0.8) T2(-12,0.8) T3(-11.2,0.8) T4(-10.4,0.8) T5(-9.6,0.8) T6(-8.8,0.8) T7(-8,0.8) T8(-7.2,0.8) T9(-6.4,0.8) T10(-5.6,0.8) T11(-4.8,0.8) T12(-4,0.8) T13(-3.2,0.8) T14(-2.4,0.8) T15(-1.6,0.8) T16(-0.8,0.8) T17(0,0.8) T18(0.8,0.8) T19(1.6,0.8) T20(2.4,0.8) T21(3.2,0.8) T22(4,0.8) T23(4.8,0.8) T24(5.6,0.8) T25(6.4,0.8) T26(7.2,0.8) T27(8,0.8) T28(8.8,0.8) T29(9.6,0.8) T30(10.4,0.8) T31(11.2,0.8) T32(12,0.8) T33(12.8,0.8) U1(-12.8,0) U2(-12,0) U3(-11.2,0) U4(-10.4,0) U5(-9.6,0) U6(-8.8,0) U7(-8,0) U8(-7.2,0) U9(-6.4,0) U10(-5.6,0) U11(-4.8,0) U12(-4,0) U13(-3.2,0) U14(-2.4,0) U15(-1.6,0) U16(-0.8,0) U17(0,0) U18(0.8,0) U19(1.6,0) U20(2.4,0) U21(3.2,0) U22(4,0) U23(4.8,0) U24(5.6,0) U25(6.4,0) U26(7.2,0) U27(8,0) U28(8.8,0) U29(9.6,0) U30(10.4,0) U31(11.2,0) U32(12,0) U33(12.8,0) V1(-12.8,-0.8) V2(-12,-0.8) V3(-11.2,-0.8) V4(-10.4,-0.8) V5(-9.6,-0.8) V6(-8.8,-0.8) V7(-8,-0.8) V8(-7.2,-0.8) V9(-6.4,-0.8) V10(-5.6,-0.8) V11(-4.8,-0.8) V12(-4,-0.8) V13(-3.2,-0.8) V14(-2.4,-0.8) V15(-1.6,-0.8) V16(-0.8,-0.8) V17(0,-0.8) V18(0.8,-0.8) V19(1.6,-0.8) V20(2.4,-0.8) V21(3.2,-0.8) V22(4,-0.8) V23(4.8,-0.8) V24(5.6,-0.8) V25(6.4,-0.8) V26(7.2,-0.8) V27(8,-0.8) V28(8.8,-0.8) V29(9.6,-0.8) V30(10.4,-0.8) V31(11.2,-0.8) V32(12,-0.8) V33(12.8,-0.8) W1(-12.8,-1.6) W2(-12,-1.6) W3(-11.2,-1.6) W4(-10.4,-1.6) W5(-9.6,-1.6) W6(-8.8,-1.6) W7(-8,-1.6) W8(-7.2,-1.6) W9(-6.4,-1.6) W10(-5.6,-1.6) W11(-4.8,-1.6) W12(-4,-1.6) W13(-3.2,-1.6) W14(-2.4,-1.6) W15(-1.6,-1.6) W16(-0.8,-1.6) W17(0,-1.6) W18(0.8,-1.6) W19(1.6,-1.6) W20(2.4,-1.6) W21(3.2,-1.6) W22(4,-1.6) W23(4.8,-1.6) W24(5.6,-1.6) W25(6.4,-1.6) W26(7.2,-1.6) W27(8,-1.6) W28(8.8,-1.6) W29(9.6,-1.6) W30(10.4,-1.6) W31(11.2,-1.6) W32(12,-1.6) W33(12.8,-1.6) Y1(-12.8,-2.4) Y2(-12,-2.4) Y3(-11.2,-2.4) Y4(-10.4,-2.4) Y5(-9.6,-2.4) Y6(-8.8,-2.4) Y7(-8,-2.4) Y8(-7.2,-2.4) Y9(-6.4,-2.4) Y10(-5.6,-2.4) Y11(-4.8,-2.4) Y12(-4,-2.4) Y13(-3.2,-2.4) Y14(-2.4,-2.4) Y15(-1.6,-2.4) Y16(-0.8,-2.4) Y17(0,-2.4) Y18(0.8,-2.4) Y19(1.6,-2.4) Y20(2.4,-2.4) Y21(3.2,-2.4) Y22(4,-2.4) Y23(4.8,-2.4) Y24(5.6,-2.4) Y25(6.4,-2.4) Y26(7.2,-2.4) Y27(8,-2.4) Y28(8.8,-2.4) Y29(9.6,-2.4) Y30(10.4,-2.4) Y31(11.2,-2.4) Y32(12,-2.4) Y33(12.8,-2.4)
