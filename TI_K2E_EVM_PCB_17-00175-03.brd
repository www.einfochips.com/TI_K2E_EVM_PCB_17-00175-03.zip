# Allegro board TI_K2E_EVM_PCB_17-00175-03.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
XDS_1V2 on L8_SIG3: 140.74,103.07 142.16,103.07 143.05,102.18 143.05,88.41 142.27,87.62 142.25,87.65 130.74,87.65 130.58,87.49 130.58,75.9 131.62,74.85 148.92,74.85 154.94,80.87 154.94,89.41 155.6,90.07 155.63,90.07 156.44,90.88 164.87,90.88 166.47,92.48 166.47,96.8 164.85,98.42 158.29,98.42 158.25,98.46 156.25,98.46 154.94,99.77 154.94,109.22 153.82,110.34 140.18,110.34 139.57,109.73 139.57,104.24
XDS_1V8 on TOP (solid shape): 146.46,93.78 146.46,91.16 146.05,90.75 143.43,90.75 143.08,91.11 143.08,93.6 143.48,94.01 146.23,94.01
XDS_1V8 on TOP (solid shape): 155.5,82.98 155.5,81.76 155.45,81.71 152.6,81.71 152.37,81.48 150.55,81.48 150.34,81.69 149.1,81.69 149.02,81.76 145.21,81.76 145.19,81.79 145.19,81.97 145.34,82.12 146.05,82.12 146.35,82.42 150.14,82.42 150.98,83.26 155.22,83.26
XDS_1V8 on L10_SIG4: 141.83,90.96 137.52,95.28 115.02,95.28 108.66,101.64 108.66,112.95 108.89,113.18 111.51,113.18 113.51,111.18 113.51,103.36 117.06,99.81 135.92,99.81 136.02,99.91 136.02,102.64 136.55,103.17 136.55,108.64 137.52,109.61 146.77,109.61 149.48,106.91 149.48,89.59 153.31,85.75 155.8,85.75 156.97,86.92 161.09,86.92 162.03,85.98 162.03,83.72 160.05,81.74 144.86,81.74 141.83,84.76
XDS_USB_GND on BOTTOM: 175.39,95.91 179.12,95.91 179.68,96.47 179.68,107.31 179.6,107.39 177.19,107.39 177.04,107.24 177.04,106.45 176.73,106.15 175.11,106.15 174.93,105.97 174.93,96.37
XDS_USB_VBUS on TOP (solid shape): 144.09,80.01 144.09,76.71 144.04,76.66 143.61,76.66 143.56,76.71 143.56,79.02 143.71,79.17 143.71,80.01 143.81,80.11 143.99,80.11
XDS_USB_VBUS on TOP (solid shape): 138.77,86.35 138.77,84.8 138.71,84.73 138.71,80.87 138.66,80.82 138.07,80.82 137.95,80.95 137.95,86.39 138,86.44 138.68,86.44
XDS_USB_VBUS on TOP (solid shape): 142.88,85.37 142.88,84 143.54,83.34 143.54,82.27 143.46,82.19 143.33,82.19 143.26,82.27 143.26,82.42 142.24,83.44 142.24,85.39 142.32,85.47 142.77,85.47
XDS_USB_VBUS on TOP (solid shape): 149.28,84.07 149.28,82.93 149.1,82.75 148.79,82.75 148.64,82.91 145.87,82.91 145.67,82.7 145.47,82.7 144.96,82.19 144.83,82.19 144.75,82.27 144.75,83.34 145.11,83.69 145.62,83.69 146.1,84.18 149.17,84.18
XDS_USB_VBUS on TOP (solid shape): 166.37,97 166.37,94.61 166.62,94.36 167.89,94.36 168.15,94.11 168.15,92.58 168.02,92.46 166.12,92.46 165.86,92.71 165.86,93.98 165.48,94.36 165.48,97.03 165.61,97.16 166.22,97.16
XDS_USB_VBUS on L3_SIG1: 153.14,95.99 153.14,85.7 154.51,84.33 164.59,84.33 167.92,87.66 167.92,100.76 170.99,103.84 173.99,103.84 174.35,104.19 174.35,108.86 173.86,109.35 169.29,109.35 168.22,108.28 166.29,108.28 161.85,103.84 161.85,100.99 159.69,98.83 159.69,94.18 159.38,93.88 156.59,93.88 155.37,95.1 155.37,95.89 154.94,96.32 153.47,96.32
XDS_VBUS on TOP: 168.02,97.66 168.28,97.41 168.28,94.61 169.04,93.85 169.04,92.71 169.29,92.46 170.18,92.46 170.31,92.58 170.31,94.92 169.57,95.66 169.57,98.15 169.72,98.3 171.73,98.3 172.34,98.91 172.34,100.23 172.06,100.51 170.56,100.51 169.9,101.17 169.9,102.18 168.96,103.12 165.81,103.12 165.71,103.02 165.71,101.63 165.96,101.37 167.11,101.37 167.61,101.88 168.12,101.88 168.48,101.52 168.48,99.87 168.02,99.42
XDS_VCC3V3 on TOP (solid shape): 145.49,89.38 145.49,88.24 145.31,88.06 144.35,88.06 144.27,87.99 144.27,85.6 144.02,85.34 144.02,84.33 143.89,84.2 143.38,84.2 143.26,84.33 143.26,87.25 143.38,87.38 143.38,89.56 143.46,89.64 145.24,89.64
XDS_VCC3V3 on BOTTOM (solid shape): 165.58,100.08 165.58,98.02 165.43,97.87 164.52,97.87 164.11,98.27 164.11,100.05 164.21,100.15 165.51,100.15
XDS_VCC3V3 on TOP: 121.78,98.41 121.83,98.35 123.1,98.35 123.4,98.66 123.4,101.07 123.27,101.2 122.04,101.2 121.78,100.94
XDS_VCC3V3 on BOTTOM: 135.74,97.04 137.07,97.04 137.34,97.3 137.34,98.03 138.19,98.88 139.81,98.88 139.97,98.72 139.97,98.29 141.76,98.29 141.98,98.52 141.98,99.35 141.82,99.51 141.51,99.51 141.39,99.39 135.59,99.39 135.46,99.26 135.46,97.32
XDS_VCC3V3 on L4_PWR1: 141.23,86.31 145.78,86.31 147.09,85 159.48,85 160.16,84.32 163.29,84.32 167.64,88.67 167.64,89.02 167.64,89.02 167.64,100.37 166.91,101.11 166.91,104.8 166.14,105.56 166.14,109.63 165.33,110.44 160.15,110.44 158.47,112.12 158.47,112.6 159.31,113.44 159.31,115.06 152.6,121.77 124.66,121.77 123.49,120.6 118.26,120.6 117.5,119.84 110.49,119.84 109.46,118.81 109.46,112.69 109.46,112.68 110.21,111.94 111.26,111.94 112.3,110.9 112.3,104.35 110.46,102.51 110.46,99.29 113.21,96.55 124.96,96.55 137.31,84.2 139.12,84.2
N14711749 on TOP: 111.38,134.59 111.58,134.39 112.24,134.39 112.42,134.57 112.42,137.19 112.78,137.54 112.78,139.45 112.7,139.52 111.61,139.52 111.38,139.29
N17204930 on BOTTOM: 148.46,17.02 148.34,16.89 148.34,16.38 148.46,16.26 153.67,16.26 153.8,16.38 153.8,16.64 153.67,16.76 153.29,16.76 153.03,17.02
N17705392 on TOP: 124.49,56.34 124.1,55.96 124.1,53.14 124.33,52.91 127.36,52.91 127.76,53.31 127.76,54.11 128.27,54.62 130.77,54.62 130.99,54.84 130.99,56.49 130.96,56.52 130.4,56.52 130.23,56.34
N17705627 on TOP: 139.74,59.75 139.62,59.87 137.85,59.87 137.39,59.41 137.39,57.61 137.11,57.33 135.84,57.33 135.76,57.25 135.76,56.54 135.81,56.49 136.49,56.49 137.01,55.98 137.01,53.34 137.06,53.29 137.77,53.29 137.92,53.44 137.92,54.28 138.1,54.46 139.53,54.46 139.74,54.67
N17709056 on TOP: 163.83,70.79 164.11,71.07 164.11,72.24 163.84,72.5 155.92,72.5 155.7,72.29 155.7,70.59 155.75,70.54 156.21,70.54 156.46,70.79
N17709291 on TOP: 147.55,67.26 148.84,67.26 149.3,67.72 149.3,69.52 149.58,69.8 150.98,69.8 151.16,69.98 151.16,70.51 151.03,70.64 150.04,70.64 149.68,70.99 149.68,73.38 148.88,74.18 148.88,74.51 148.84,74.55 147.98,74.55 147.89,74.46 147.89,73.8 147.27,73.18 147.27,67.54
N17726206 on TOP: 127.51,135.15 127.51,133.4 127.74,133.17 127.74,131.88 127.61,131.75 127.61,130.45 127.71,130.35 129.62,130.35 129.82,130.56 129.82,131.22 129.62,131.42 128.88,131.42 128.73,131.57 128.73,135.03 128.45,135.31 127.66,135.31
N17728755 on BOTTOM: 118.87,34.34 117.63,34.34 117.55,34.26 117.55,32.66 118.11,32.11 122.25,32.11 122.33,32.18 122.33,33.32 122.25,33.4 120.83,33.4 120.78,33.35 120.78,32.82 120.7,32.74 119.18,32.74 118.95,32.97 118.95,34.26
N17929864 on BOTTOM: 148.84,89.1 149.07,88.87 149.07,88.37 149.02,88.32 148.21,88.32 147.96,88.57 147.96,92.3 147.52,92.74 147.52,95.22 149.2,96.9 149.2,99.16 148.64,99.72 148.64,100.18 148.82,100.36 150.09,100.36 150.27,100.18 150.27,96.47 148.84,95.05
N17941980 on BOTTOM (solid shape): 161.29,109.73 161.29,106.43 161.14,106.27 159.97,106.27 159.66,106.58 159.66,109.73 160.07,110.13 160.88,110.13
N18360137 on BOTTOM: 151.82,23.5 152.53,23.5 152.65,23.62 152.65,24.51 152.78,24.64 155.55,24.64 155.65,24.74 155.65,25.35 155.54,25.46 151.57,25.46 151.51,25.4 151.51,24.64 151.64,24.51 151.64,23.67
N19617114 on TOP (solid shape): 143.54,80.04 143.54,79.27 142.52,78.26 142.14,78.26 141.4,77.52 140.54,77.52 140.45,77.6 140.45,79.27 140.69,79.5 142.62,79.5 143.23,80.11 143.46,80.11
N22090501 on TOP: 66.95,9.37 72.44,9.37 72.52,9.3 72.52,7.52 72.62,7.42 74.32,7.42 74.45,7.54 74.45,8.99 74.93,9.47 76.15,9.47 76.4,9.73 76.4,13.89 76.17,14.12 69.24,14.12 66.78,11.66 66.78,9.55
N22090505 on TOP (solid shape): 70.23,9.07 70.23,8.28 70.13,8.18 69.8,8.18 69.65,8.33 69.65,8.59 69.39,8.84 66.83,8.84 66.73,8.94 66.73,9.12 66.78,9.17 70.13,9.17
N22090506 on TOP: 72.06,8.99 72.06,8.36 71.98,8.28 70.61,8.28 70.59,8.31 70.59,8.89 70.71,9.02 72.03,9.02
N22090514 on TOP: 62.56,9.27 62.71,9.42 62.71,11.58 62.64,11.66 61.82,11.66 61.72,11.56 51.84,11.56 51.59,11.81 43.46,11.81 43.15,11.51 43.15,4.72 43.94,3.94 48.9,3.94 50.27,5.31 50.27,7.57 50.85,8.15 53.37,8.15 54.48,9.27
N22090514 on BOTTOM: 43.43,12.29 43.43,5.59 43.74,5.28 47.5,5.28 47.88,5.66 47.88,12.34 47.42,12.8 43.94,12.8
N22090558 on TOP: 89.49,16.24 94.5,16.24 95.2,15.54 96.04,15.54 96.6,14.99 97.79,14.99 98.04,14.73 98.04,13.84 97.79,13.59 96.82,13.59 96.44,13.97 89.62,13.97 89.47,14.12 89.47,16.22
N22090568 on TOP (solid shape): 113.16,14.05 113.16,12.78 113.03,12.65 107.75,12.65 107.21,12.12 103.84,12.12 103.73,12.22 103.73,12.93 103.76,12.95 106.71,12.95 107.98,14.22 112.98,14.22
N22090568 on TOP (solid shape): 89.28,13.72 94.49,13.72 94.74,13.46 97.79,13.46 97.92,13.34 97.92,12.7 97.79,12.57 96.52,12.57 96.27,12.32 83.06,12.32 82.3,13.08 82.3,14.86 83.06,15.62 87.38,15.62
N22090568 on BOTTOM (solid shape): 85.39,15.39 85.39,12.9 85.01,12.52 80.95,12.52 80.57,12.9 80.57,15.67 80.75,15.85 84.94,15.85
N22090568 on L3_SIG1: 82.7,14.86 82.7,11.35 85.5,8.56 97.69,8.56 98.09,8.15 98.09,6.76 98.7,6.15 98.7,5.23 99.16,4.78 103.02,4.78 103.28,5.03 103.28,6.05 102.84,6.48 101.27,6.48 101.09,6.65 101.09,8.18 102.23,9.32 111.91,9.32 113.28,10.69 113.28,18.49 112.01,19.76 87.6,19.76
N22090583 on TOP (solid shape): 97.92,11.18 97.92,10.41 97.66,10.16 96.52,10.16 96.39,10.03 96.39,9.53 96.14,9.27 95.12,9.27 95,9.14 95,8.51 94.63,8.14 89.75,8.14 89.66,8.22 89.66,10.29 89.92,10.54 94.87,10.54 95.12,10.79 96.01,10.79 96.65,11.43 97.66,11.43
N22090598 on TOP (solid shape): 107.57,10.54 112.37,10.54 112.83,10.08 112.83,8.66 112.38,8.21 107.35,8.21 106.93,8.64 106.15,8.64 105.97,8.81 105.97,11.13 105.51,11.58 103.73,11.58 103.68,11.63 103.68,11.94 103.71,11.96 106.15,11.96
N22090602 on TOP (solid shape): 112.52,17.32 112.52,15.11 112.46,15.05 108.01,15.05 106.93,13.97 106.93,13.69 106.35,13.11 103.78,13.11 103.68,13.21 103.68,13.41 103.73,13.46 105.71,13.46 105.94,13.69 105.94,15.77 106.1,15.93 106.71,15.93 107.09,16.31 107.09,17.2 107.41,17.52 112.33,17.52
N22090668 on TOP: 74.93,8.71 75.31,9.09 76.68,9.09 76.99,8.79 76.99,6.02 76.78,5.82 74.98,5.82 74.93,5.87

Small or netless copper shapes (teardrops, artwork): 1 on BOTTOM

## Text on the board
Ref Des/Silkscreen Bottom: 86 | 170 | z3 | K1 | L1 | PCA REV : 18_00175_03 | PCB REV : 17_00175_03 | 2 | AN1 | z4 | M1 | I1 | J1 | z2 | 1 | A | A33 | MADE IN INDIA | z1 | G1 | H1 | D1 | F1 | W | z7 | B1 | 19 | C1 | A1 | z6 | z5
User.Comments: UNLESS OTHERWISE SPECIFIED | ALL DIMENSIONS ARE IN | INCHES | DATE | REV | - | 1 | MILLIMETERS | CHANGES IN FAB DETAILS & IMPEDANCE DETAILS | INITIAL RELEASE | SIZE | SCALE | DRAWING TITLE | PART NUMBER | 1/1 | DESCRIPTION | REVISIONS | 04/03/2014 | SHEET | 1  OF | Library | QA & CAM | APPROVED | 04-03-2014 | 03 | D | eINFOCHIPS LIMITED | X
Ref Des/Silkscreen Top: 1 | 85 | Q | Designed by: | TEXAS INSTRUMENTS | www.einfochips.com | TMDXEVM66AK2E | The Solutions people | V | K | E | J | O | N | P | AA | H | L | AB | I | M | 59 | 71 | R | 2 | A | S | 72 | G | D | F | U | B | T | C | 62 | 61
DIMENSION: TYPICAL | 45+/-2 | NOTE. | NOTES: UNLESS OTHERWISE SPECIFIED. | 10. MINIMUM CONDUCTOR WIDTH:4.0 MILS | 11. THE PCB EDGE NEAR AMC CONNECTOR EDGE SHOULD BE AS SHOWN IN THE BELOW FIG. | 12. THE ALL DIMENSIONS ARE IN "MM [INCHES]". | REQUIREMENTS. | COPPER: AS PER STACKUP. | DIELECTRIC: FR4_ITEQ IT168G. | U.L. RATING: 94V-0 MINIMUM | 1. FABRICATE PER IPC-6012A CLASS 2. | 3. SURFACE FINISH:  ENIG | 6. 100% CONTINUITY TESTING USING DATABASE NETLIST SHALL BE PERFORMED, | VENDOR TO IDENTIFY TEST PASSED IN SECONDARY  SIDE. | 4. SOLDER MASK MATERIAL SHALL MEET ALL THE REQUIREMENTS OF | IPC-SM-840C AND SHALL BE GREEN IN COLOR AND APPLIED OVER BARE COPPER. | 7. VENDOR TO MARK DATE CODE AND LOGO  IN ETCH OR IN LEGEND. | 5. SILK SCREEN LEGEND TO BE APPLIED PER LAYER STACKUP USING WHITE | NON-CONDUCTIVE EPOXY INK. | 9. DIELECTRICS AND LINEWIDTHS MAY BE ADJUSTED TO MEET THE IMPEDANCE | 8. BOW AND TWIST SHALL NOT EXCEED 0.7% OF LONGEST SIDE . | "Inner layer non-functional via pads must be removed from all serdes vias and RTM connector pins". | MINIMUM SPACING:3.8 MILS | SCALE: NONE | FABRICATION DRAWING | TMDXEVM66AK2E | SENSITIVE ELECTRONIC DEVICES-CLASS 1 | CAUTION | SCORE DETAIL
PAGE_OUTLINE: 63.036 MILS +/-10% | PRIMARY SIDE, SILK SCREEN | PRIMARY SIDE, SOLDER MASK - 2 MILS | PRIMARY SIDE, LAYER 1     - 1.794 MILS | DIELECTRIC                - 3.596 MILS | INNER LAYER, LAYER 3      - 1.26 MILS | SECONDARY SIDE, LAYER 12    - 1.794 MILS | SECONDARY SIDE, SOLDER MASK - 2 MILS | GROUND LAYER, LAYER 2     - 1.26 MILS | DIELECTRIC                - 5 MILS | INNER LAYER, LAYER 5      - 1.26 MILS | DIELECTRIC                - 3.814 MILS | DIELECTRIC                - 4 MILS | GROUND LAYER, LAYER 7     - 1.26 MILS | DIELECTRIC                - 5.014 MILS | POWER LAYER, LAYER 4      - 1.26 MILS | GROUND LAYER, LAYER 6     - 1.26 MILS | INNER LAYER, LAYER 8      - 1.26 MILS | POWER LAYER, LAYER 9      - 1.26 MILS | INNER LAYER, LAYER 10     - 1.26 MILS | GROUND LAYER, LAYER 11    - 1.26 MILS | SECONDARY SIDE, SILK SCREEN | CAD | DATA | DO NOT MANUALLY | UPDATE | D | C | B | A | 8 | 7 | 6 | 5 | 4 | 3 | 2 | 1
User.8: A | K | J | D | G | F | E | B | C | L
User.9: A | z1 | C | D | E | B | L | H | N | Z | z2 | G | J | M | K | F
User.10: LAYER NO. | L10_SIG4 | L12_BOT | L03_SIG1 | L01_TOP | L05_SIG2 | L08_SIG3 | CONDUCTOR WIDTH | 4 MILS | 4.5 MILS | 6 MILS | 4.2 MILS | 7.5 MILS | SPACING | SINGLE ENDED | DIFFERENTIAL 90E | DIFFERENTIAL 100E | REFERENCE LAYER | L06_GND2 | L07_GND3 | L11_GND4 | L02_GND1 | IMPEDANCE +/-10% | 50 OHMS | 90 OHMS | 100 OHMS | NOT USED
User.11: DATE:14-08-2014 | DESIGNED AT:eINFOCHIPS LIMITED | PART NO/CARD REF:K2E_EVM_CARD | FILM LAYER: | COMPANY NAME : eINFOCHIPS  LIMITED | JOB NUMBER:EINF4982B | REV:03
User.12: 1 | PRIMARY SIDE
User.13: 2 | LAYER2
User.14: 3 | LAYER3
User.15: 4 | LAYER4
User.16: 5 | LAYER5
User.17: 6 | LAYER6
User.18: 7 | LAYER7
User.19: 8 | LAYER8
User.20: 9 | LAYER9
User.21: 10 | LAYER 10
User.22: 11 | LAYER 11
User.23: 12 | SECONDARY SIDE
User.24: FABRICATION LAYER
User.25: SOLDERMASK PRIMARY SIDE
User.26: SOLDERMASK SECONDARY SIDE
User.27: SOLDER PASTE PRIMARY SIDE
User.28: SOLDER PASTE SECONDARY SIDE
User.29: ASSEMBLY PRIMARY SIDE
User.30: ASSEMBLY SECONDARY SIDE
User.31: SILKSCREEN PRIMARY SIDE
User.32: SILKSCREEN SECONDARY SIDE
User.35: 0.4+/-0.1mm | 63.036Mil[1.60MM] | PCB THICKNESS
User.36: ESWAR
User.38: FIGURE | SIZE | 8.0 | 10.0 | 11.81 | 12.0 | 14.0 | 16.0 | 18.0 | 28.0 | 32.0 | 35.43 | 40.0 | 42.0 | 45.0 | 51.0 | 53.0 | 61.81 | 91.0 | 106.0 | 125.0 | 156.0 | 26.0 | 43.0 | 47.0 | 63.0 | 89.0 | 92.52 | 127.95 | 138.0 | 75.0x28.0 | 75.0x38.0 | 98.43x39.37 | 118.11x39.37 | 137.8x39.37 | 421.0x67.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +0.0/-0.0 | +2.0/-2.0 | +2.0/-0.0 | PLATED | NON-PLATED | QTY | 2617 | 927 | 55 | 89 | 314 | 126 | 320 | 19 | 17 | 24 | 39 | 2 | 5 | 4 | 1
