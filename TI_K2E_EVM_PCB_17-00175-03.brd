# Allegro board TI_K2E_EVM_PCB_17-00175-03.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SOIC127P600_8
  rect 2.21x0.61 smd: 1(-2.6,1.905) 2(-2.6,0.635) 3(-2.6,-0.635) 4(-2.6,-1.905) 5(2.6,-1.905) 6(2.6,-0.635) 7(2.6,0.635) 8(2.6,1.905)
SOIC127P1032_16
  rect 2.21x0.61 smd: 1(-4.6,4.445) 2(-4.6,3.175) 3(-4.6,1.905) 4(-4.6,0.635) 5(-4.6,-0.635) 6(-4.6,-1.905) 7(-4.6,-3.175) 8(-4.6,-4.445) 9(4.6,-4.445) 10(4.6,-3.175) 11(4.6,-1.905) 12(4.6,-0.635) 13(4.6,0.635) 14(4.6,1.905) 15(4.6,3.175) 16(4.6,4.445)
SOIC_8P_20_79X122
  oval 0.279x1.041 smd: 1(-0.75,-1.539) 2(-0.25,-1.539) 3(0.25,-1.539) 4(0.75,-1.539) 5(0.75,1.539) 6(0.25,1.539) 7(-0.25,1.539) 8(-0.75,1.539)
SOIC_8P_50_193X236
  oval 0.533x1.397 smd: 1(-1.905,-2.809) 2(-0.635,-2.809) 3(0.635,-2.809) 4(1.905,-2.809) 5(1.905,2.809) 6(0.635,2.809) 7(-0.635,2.809) 8(-1.905,2.809)
SOIC_16P_26_197X252
  oval 0.356x1.372 smd: 1(-2.275,-3.022) 2(-1.625,-3.022) 3(-0.975,-3.022) 4(-0.325,-3.022) 5(0.325,-3.022) 6(0.975,-3.022) 7(1.625,-3.022) 8(2.275,-3.022) 9(2.275,3.022) 10(1.625,3.022) 11(0.975,3.022) 12(0.325,3.022) 13(-0.325,3.022) 14(-0.975,3.022) 15(-1.625,3.022) 16(-2.275,3.022)
SOIC_20P_26_256X252
  oval 0.356x1.397 smd: 1(-2.925,-3.014) 2(-2.275,-3.014) 3(-1.625,-3.014) 4(-0.975,-3.014) 5(-0.325,-3.014) 6(0.325,-3.014) 7(0.975,-3.014) 8(1.625,-3.014) 9(2.275,-3.014) 10(2.925,-3.014) 11(2.925,3.014) 12(2.275,3.014) 13(1.625,3.014) 14(0.975,3.014) 15(0.325,3.014) 16(-0.325,3.014) 17(-0.975,3.014) 18(-1.625,3.014) 19(-2.275,3.014) 20(-2.925,3.014)
SOIC_28P_26_402X307
  oval 0.356x1.651 smd: 1(-4.225,-3.577) 2(-3.575,-3.577) 3(-2.925,-3.577) 4(-2.275,-3.577) 5(-1.625,-3.577) 6(-0.975,-3.577) 7(-0.325,-3.577) 8(0.325,-3.577) 9(0.975,-3.577) 10(1.625,-3.577) 11(2.275,-3.577) 12(2.925,-3.577) 13(3.575,-3.577) 14(4.225,-3.577) 15(4.225,3.577) 16(3.575,3.577) 17(2.925,3.577) 18(2.275,3.577) 19(1.625,3.577) 20(0.975,3.577) 21(0.325,3.577) 22(-0.325,3.577) 23(-0.975,3.577) 24(-1.625,3.577) 25(-2.275,3.577) 26(-2.925,3.577) 27(-3.575,3.577) 28(-4.225,3.577)
SON_6P_20_59X39
  rect 0.305x0.559 smd: 1(-0.5,-0.377) 2(0,-0.377) 3(0.5,-0.377) 4(0.5,0.377) 5(0,0.377) 6(-0.5,0.377)
SOT23
  rect 0.991x1.397 smd: 1(-0.953,-1.105) 2(0.953,-1.105) 3(0,1.105)
SOT23_6
  rect 0.686x0.991 smd: 1(-0.95,-1.285) 2(0,-1.285) 3(0.95,-1.285) 4(0.95,1.285) 5(0,1.285) 6(-0.95,1.285)
SOT416_3P
  rect 0.406x1.346 smd: 1(-0.5,-0.8) 2(0.5,-0.8) 3(0,0.8)
SOT-23
  oval 1.219x0.508 smd: 1(-1.302,0.95) 2(-1.302,-0.95) 3(1.302,0)
SOT-23_5P
  oval 0.533x1.118 smd: 1(-0.95,-1.352) 2(0,-1.352) 3(0.95,-1.352) 4(0.95,1.352) 5(-0.95,1.352)
SOT-223
  oval 0.864x1.651 smd: 1(-2.3,-3.177) 2(0,-3.177) 3(2.3,-3.177)
  rect 2.997x1.651 smd: 4(0,3.177)
SSOP65P640_14
  rect 0.483x1.575 smd: 1(-1.95,-2.875) 2(-1.3,-2.875) 3(-0.65,-2.875) 4(0,-2.875) 5(0.65,-2.875) 6(1.3,-2.875) 7(1.95,-2.875) 8(1.95,2.875) 9(1.3,2.875) 10(0.65,2.875) 11(0,2.875) 12(-0.65,2.875) 13(-1.3,2.875) 14(-1.95,2.875)
SW_EVQ-PF104R
  rect 1.422x1.422 hole 1.016: 1(0,0)
  round 1.422 hole 1.016: 2(4.5,0)
  round 1.727 hole 1.295: 3(-1.25,2.5) 4(5.75,2.5)
SW_EVQ-PF206K
  rect 1.6x1.6 hole 1.016: 1(0,0)
  round 1.6 hole 1.016: 2(4.5,0)
  round 1.9 hole 1.295: SH1(-1.25,2.5) SH2(5.75,2.5)
SW_PTS635SL25SMTRLFS
  rect 2x1 smd: 1(-3,0) 2(3,0)
SW_SDA04H1SBD
  rect 1.499x2.146 smd: 1(-3.81,-4.121) 2(-1.27,-4.121) 3(1.27,-4.121) 4(3.81,-4.121) 5(3.81,4.121) 6(1.27,4.121) 7(-1.27,4.121) 8(-3.81,4.121)
TE_280371-2
  rect 1.5x1.5 hole 0.9: 1(0,0)
  round 1.5 hole 0.9: 2(2.54,0) 3(5.08,0) 4(7.62,0)
TP1-6040
  round 1.524 hole 1.016: 1(0,0)
TP28
  round 0.711 smd: 1(0,0)
TP365X205
  rect 3.65x2.05 smd: 1(0,0)
TP-S40
  round 1.016 smd: 1(0,0)
TP_15
  round 0.4 smd: 1(0,0)
TQFP44
  rect 0.508x1.524 smd: 1(-4.013,-5.715) 2(-3.2,-5.715) 3(-2.413,-5.715) 4(-1.6,-5.715) 5(-0.813,-5.715) 6(-0.025,-5.715) 7(0.787,-5.715) 8(1.575,-5.715) 9(2.388,-5.715) 10(3.2,-5.715) 11(3.988,-5.715) 23(3.988,5.715) 24(3.2,5.715) 25(2.388,5.715) 26(1.575,5.715) 27(0.787,5.715) 28(-0.025,5.715) 29(-0.813,5.715) 30(-1.6,5.715) 31(-2.413,5.715) 32(-3.2,5.715) 33(-4.013,5.715)
  rect 1.524x0.508 smd: 12(5.715,-4.013) 13(5.715,-3.2) 14(5.715,-2.413) 15(5.715,-1.6) 16(5.715,-0.813) 17(5.715,-0.025) 18(5.715,0.787) 19(5.715,1.575) 20(5.715,2.388) 21(5.715,3.2) 22(5.715,3.988) 34(-5.715,3.988) 35(-5.715,3.2) 36(-5.715,2.388) 37(-5.715,1.575) 38(-5.715,0.787) 39(-5.715,-0.025) 40(-5.715,-0.813) 41(-5.715,-1.6) 42(-5.715,-2.413) 43(-5.715,-3.2) 44(-5.715,-4.013)
TSSOP65P640_8
  rect 1.702x0.457 smd: 1(-2.85,0.975) 2(-2.85,0.325) 3(-2.85,-0.325) 4(-2.85,-0.975) 5(2.85,-0.975) 6(2.85,-0.325) 7(2.85,0.325) 8(2.85,0.975)
TSSOP65P640_14
  rect 1.88x0.33 smd: 1(-2.777,1.95) 2(-2.777,1.3) 3(-2.777,0.65) 4(-2.777,0) 5(-2.777,-0.65) 6(-2.777,-1.3) 7(-2.777,-1.95) 8(2.777,-1.95) 9(2.777,-1.3) 10(2.777,-0.65) 11(2.777,0) 12(2.777,0.65) 13(2.777,1.3) 14(2.777,1.95)
TYCO2013289-2_DDR3
  round 1.092 hole 1.092 unplated: (-65.05,-4.1)
  round 1.6 hole 1.6 unplated: (1.75,-4.1)
  rect 0.356x2.007 smd: 1(0,0) 2(-0.3,-8.2) 3(-0.6,0) 4(-0.9,-8.2) 5(-1.2,0) 6(-1.5,-8.2) 7(-1.8,0) 8(-2.1,-8.2) 9(-2.4,0) 10(-2.7,-8.2) 11(-3,0) 12(-3.3,-8.2) 13(-3.6,0) 14(-3.9,-8.2) 15(-4.2,0) 16(-4.5,-8.2) 17(-4.8,0) 18(-5.1,-8.2) 19(-5.4,0) 20(-5.7,-8.2) 21(-6,0) 22(-6.3,-8.2) 23(-6.6,0) 24(-6.9,-8.2) 25(-7.2,0) 26(-7.5,-8.2) 27(-7.8,0) 28(-8.1,-8.2) 29(-8.4,0) 30(-8.7,-8.2) 31(-9,0) 32(-9.3,-8.2) 33(-9.6,0) 34(-9.9,-8.2) 35(-10.2,0) 36(-10.5,-8.2) 37(-10.8,0) 38(-11.1,-8.2) 39(-11.4,0) 40(-11.7,-8.2) 41(-12,0) 42(-12.3,-8.2) 43(-12.6,0) 44(-12.9,-8.2) 45(-13.2,0) 46(-13.5,-8.2) 47(-13.8,0) 48(-14.1,-8.2) 49(-14.4,0) 50(-14.7,-8.2) 51(-15,0) 52(-15.3,-8.2) 53(-15.6,0) 54(-15.9,-8.2) 55(-16.2,0) 56(-16.5,-8.2) 57(-16.8,0) 58(-17.1,-8.2) 59(-17.4,0) 60(-17.7,-8.2) 61(-18,0) 62(-18.3,-8.2) 63(-18.6,0) 64(-18.9,-8.2) 65(-19.2,0) 66(-19.5,-8.2) 67(-19.8,0) 68(-20.1,-8.2) 69(-20.4,0) 70(-20.7,-8.2) 71(-21,0) 72(-21.3,-8.2) 73(-24,0) 74(-24.3,-8.2) 75(-24.6,0) 76(-24.9,-8.2) 77(-25.2,0) 78(-25.5,-8.2) 79(-25.8,0) 80(-26.1,-8.2) 81(-26.4,0) 82(-26.7,-8.2) 83(-27,0) 84(-27.3,-8.2) 85(-27.6,0) 86(-27.9,-8.2) 87(-28.2,0) 88(-28.5,-8.2) 89(-28.8,0) 90(-29.1,-8.2) 91(-29.4,0) 92(-29.7,-8.2) 93(-30,0) 94(-30.3,-8.2) 95(-30.6,0) 96(-30.9,-8.2) 97(-31.2,0) 98(-31.5,-8.2) 99(-31.8,0) 100(-32.1,-8.2) 101(-32.4,0) 102(-32.7,-8.2) 103(-33,0) 104(-33.3,-8.2) 105(-33.6,0) 106(-33.9,-8.2) 107(-34.2,0) 108(-34.5,-8.2) 109(-34.8,0) 110(-35.1,-8.2) 111(-35.4,0) 112(-35.7,-8.2) 113(-36,0) 114(-36.3,-8.2) 115(-36.6,0) 116(-36.9,-8.2) 117(-37.2,0) 118(-37.5,-8.2) 119(-37.8,0) 120(-38.1,-8.2) 121(-38.4,0) 122(-38.7,-8.2) 123(-39,0) 124(-39.3,-8.2) 125(-39.6,0) 126(-39.9,-8.2) 127(-40.2,0) 128(-40.5,-8.2) 129(-40.8,0) 130(-41.1,-8.2) 131(-41.4,0) 132(-41.7,-8.2) 133(-42,0) 134(-42.3,-8.2) 135(-42.6,0) 136(-42.9,-8.2) 137(-43.2,0) 138(-43.5,-8.2) 139(-43.8,0) 140(-44.1,-8.2) 141(-44.4,0) 142(-44.7,-8.2) 143(-45,0) 144(-45.3,-8.2) 145(-45.6,0) 146(-45.9,-8.2) 147(-46.2,0) 148(-46.5,-8.2) 149(-46.8,0) 150(-47.1,-8.2) 151(-47.4,0) 152(-47.7,-8.2) 153(-48,0) 154(-48.3,-8.2) 155(-48.6,0) 156(-48.9,-8.2) 157(-49.2,0) 158(-49.5,-8.2) 159(-49.8,0) 160(-50.1,-8.2) 161(-50.4,0) 162(-50.7,-8.2) 163(-51,0) 164(-51.3,-8.2) 165(-51.6,0) 166(-51.9,-8.2) 167(-52.2,0) 168(-52.5,-8.2) 169(-52.8,0) 170(-53.1,-8.2) 171(-53.4,0) 172(-53.7,-8.2) 173(-54,0) 174(-54.3,-8.2) 175(-54.6,0) 176(-54.9,-8.2) 177(-55.2,0) 178(-55.5,-8.2) 179(-55.8,0) 180(-56.1,-8.2) 181(-56.4,0) 182(-56.7,-8.2) 183(-57,0) 184(-57.3,-8.2) 185(-57.6,0) 186(-57.9,-8.2) 187(-58.2,0) 188(-58.5,-8.2) 189(-58.8,0) 190(-59.1,-8.2) 191(-59.4,0) 192(-59.7,-8.2) 193(-60,0) 194(-60.3,-8.2) 195(-60.6,0) 196(-60.9,-8.2) 197(-61.2,0) 198(-61.5,-8.2) 199(-61.8,0) 200(-62.1,-8.2) 201(-62.4,0) 202(-62.7,-8.2) 203(-63,0) 204(-63.3,-8.2)
  rect 3.505x4.597 smd: G1(1.15,-16.1) G2(-64.45,-16.1)
VFBGA54C80P9X9_800X800X100_EINF
  round 0.4 smd: A1(-3.2,3.2) A2(-2.4,3.2) A3(-1.6,3.2) A7(1.6,3.2) A8(2.4,3.2) A9(3.2,3.2) B1(-3.2,2.4) B2(-2.4,2.4) B3(-1.6,2.4) B7(1.6,2.4) B8(2.4,2.4) B9(3.2,2.4) C1(-3.2,1.6) C2(-2.4,1.6) C3(-1.6,1.6) C7(1.6,1.6) C8(2.4,1.6) C9(3.2,1.6) D1(-3.2,0.8) D2(-2.4,0.8) D3(-1.6,0.8) D7(1.6,0.8) D8(2.4,0.8) D9(3.2,0.8) E1(-3.2,0) E2(-2.4,0) E3(-1.6,0) E7(1.6,0) E8(2.4,0) E9(3.2,0) F1(-3.2,-0.8) F2(-2.4,-0.8) F3(-1.6,-0.8) F7(1.6,-0.8) F8(2.4,-0.8) F9(3.2,-0.8) G1(-3.2,-1.6) G2(-2.4,-1.6) G3(-1.6,-1.6) G7(1.6,-1.6) G8(2.4,-1.6) G9(3.2,-1.6) H1(-3.2,-2.4) H2(-2.4,-2.4) H3(-1.6,-2.4) H7(1.6,-2.4) H8(2.4,-2.4) H9(3.2,-2.4) J1(-3.2,-3.2) J2(-2.4,-3.2) J3(-1.6,-3.2) J7(1.6,-3.2) J8(2.4,-3.2) J9(3.2,-3.2)
VQFN50P450X350X100-21N_EINF
  custom 0.07x0.07 smd: 1(-2.225,-0.75) 2(-1.75,-1.725) 3(-1.25,-1.725) 4(-0.75,-1.725) 5(-0.25,-1.725) 6(0.25,-1.725) 7(0.75,-1.725) 8(1.25,-1.725) 9(1.75,-1.725) 10(2.225,-0.75) 11(2.225,0.75) 12(1.75,1.725) 13(1.25,1.725) 14(0.75,1.725) 15(0.25,1.725) 16(-0.25,1.725) 17(-0.75,1.725) 18(-1.25,1.725) 19(-1.75,1.725) 20(-2.225,0.75)
  rect 3.05x2.05 smd: 21(0,0)
VSSOP50P310_8
  rect 1.346x0.305 smd: 1(-1.55,0.75) 2(-1.55,0.25) 3(-1.55,-0.25) 4(-1.55,-0.75) 5(1.55,-0.75) 6(1.55,-0.25) 7(1.55,0.25) 8(1.55,0.75)
WSON50P300X300X80-11N
  rect 0.6x0.25 smd: 1(-1.4,1) 2(-1.4,0.5) 3(-1.4,0) 4(-1.4,-0.5) 5(-1.4,-1) 6(1.4,-1) 7(1.4,-0.5) 8(1.4,0) 9(1.4,0.5) 10(1.4,1)
  rect 1.6x2 smd: 11(0,0)
WURTH_692122030100
  round 1 hole 2 unplated: (0.35,-5.22) (7.15,-5.22)
  rect 0.9x2.6 smd: 1(0,0) 2(2.5,0) 3(5,0) 4(7.5,0)
  rect 0.9x2.15 smd: 5(8.75,0.225) 6(6.25,0.225) 7(3.75,0.225) 8(1.25,0.225) 9(-1.25,0.225)
  oval 2.52x3.4 hole 1.12x2: SH1(-3.05,-5.22) SH2(10.55,-5.22)
XMULTIPLE_XMH-TRJG17020AENL
  round 1 hole 3.25 unplated: (-2.42,-4.7) (9.01,-4.7)
  round 1.5 hole 0.9: 1A(0,0) 1B(6.6,0) 2A(1.27,1.27) 2B(5.33,1.27) 3A(0,2.54) 3B(6.6,2.54) 4A(1.27,3.81) 4B(5.33,3.81) 5A(0,5.08) 5B(6.6,5.08) 6A(1.27,6.35) 6B(5.33,6.35) 7A(0,7.62) 7B(6.6,7.62) 8A(1.27,8.89) 8B(5.33,8.89) 9A(0,10.16) 9B(6.6,10.16) 10A(1.27,11.43) 10B(5.33,11.43)
  round 1.62 hole 1.016: 11A(-3.69,-7.6) 11B(-3.69,7.09) 12A(-1.15,-7.6) 12B(-3.69,0.74) 13A(7.74,-7.6) 13B(10.28,3.28) 14A(10.28,-7.6) 14B(10.28,0.74)
  round 2.17 hole 1.57: SH1(-5.21,-9.27) SH2(-5.21,10.79) SH3(11.8,-9.27) SH4(11.8,6.73)
XTAL_ABM3B
  rect 1.6x1.397 smd: 1(-2.07,-1.206) 2(2.07,-1.206) 3(2.07,1.206) 4(-2.07,1.206)
XTAL_ABM7_1
  rect 1.905x2.591 smd: 1(-2.15,0) 2(2.15,0)
XTAL_ECS-120-20-3X-TR
  rect 3.5x1.2 smd: 1(-2.75,0) 2(2.75,0)
XTAL_SSPT7F
  rect 1.2x0.6 smd: 1(-3.15,-0.45) 2(3.15,-0.45) 3(3.15,0.45) 4(-3.15,0.45)

## Nets
AGND: C279.2 C281.2 R266.1 R268.1 R271.1 R275.1 R279.2 R593.2 U34.38(AGND)
AGND1: C282.1 C284.1 C820.1 C821.1 C822.2 C823.2 C851.1 C852.1 C853.1 C854.1 C856.1 R281.2 R566.1 U33.21(AGND)
AVCC3V3_1: C259.1 C274.1 C836.1 C837.1 FB35.2 U77.20(AVDD33_1) U77.25(AVDD33_2) U77.36(REG_IN)
AVCC3V3_2: C175.1 C177.1 C188.1 C195.1 C210.1 C763.1 C764.1 FB32.2 U73.20(AVDD33_1) U73.25(AVDD33_2) U73.36(REG_IN)
AVDD0: C190.2 C191.1 C192.1 C193.1 FB7.2 U75.40(AVDD0)
AVDD1: C213.2 C218.1 C221.1 C223.1 FB9.2 U75.35(AVDD1)
AVDD1V8_1: C265.1 C269.1 C271.1 C272.1 C273.1 C819.1 C827.1 C834.1 C838.1 C839.1 C840.1 C841.1 U77.3(AVDD18_1) U77.19(AVDD18_2) U77.26(AVDD18_3) U77.35(AVDDC18) U77.38(AVDD18_4) U77.39(AVDD18_OUT)
AVDD1V8_2: C204.1 C208.1 C209.1 C211.1 C212.1 C734.1 C748.1 C759.1 C773.1 C774.1 C776.1 C778.1 U73.3(AVDD18_1) U73.19(AVDD18_2) U73.26(AVDD18_3) U73.35(AVDDC18) U73.38(AVDD18_4) U73.39(AVDD18_OUT)
AVDDA1: C490.1 C491.1 FB26.1 U23.AF7(AVDDA1)
AVDDA2: C481.1 C482.1 FB21.1 U23.K7(AVDDA2)
AVDDA3: C477.1 C486.1 FB24.1 U23.AD7(AVDDA3)
DVDD1V0: C196.1 C203.1 C207.1 C217.1 C220.1 C222.1 C224.1 C227.1 Q9.3(COLLECTOR) U75.1(VDD_1) U75.4(VDD_2) U75.9(VDD_3) U75.14(VDD_4) U75.26(VDD_5) U75.46(VDD_6)
DVDD1V0_1: C818.1 C846.1 C847.1 C850.1 C855.1 U77.6(DVDD_1) U77.40(DVDD_OUT) U77.42(DVDD_2)
DVDD1V0_2: C735.1 C786.1 C787.1 C792.1 C794.1 U73.6(DVDD_1) U73.40(DVDD_OUT) U73.42(DVDD_2)
GND: AMC1.1(GND_1) AMC1.7(GND_2) AMC1.10(GND_3) AMC1.13(GND_4) AMC1.16(GND_5) AMC1.19(GND_6) AMC1.22(GND_7) AMC1.25(GND_8) AMC1.28(GND_9) AMC1.31(GND_10) AMC1.34(GND_11) AMC1.37(GND_12) AMC1.40(GND_13) AMC1.43(GND_14) AMC1.46(GND_15) AMC1.49(GND_16) AMC1.52(GND_17) AMC1.55(GND_18) AMC1.58(GND_19) AMC1.61(GND_20) AMC1.64(GND_21) AMC1.67(GND_22) AMC1.70(GND_23) AMC1.73(GND_24) AMC1.76(GND_25) AMC1.79(GND_26) AMC1.82(GND_27) AMC1.85(GND_28) AMC1.86(GND_29) AMC1.89(GND_30) AMC1.92(GND_31) AMC1.95(GND_32) AMC1.98(GND_33) AMC1.101(GND_34) AMC1.104(GND_35) AMC1.107(GND_36) AMC1.110(GND_37) AMC1.113(GND_38) AMC1.116(GND_39) AMC1.119(GND_40) AMC1.122(GND_41) AMC1.125(GND_42) AMC1.128(GND_43) AMC1.131(GND_44) AMC1.134(GND_45) AMC1.137(GND_46) AMC1.140(GND_47) AMC1.143(GND_48) AMC1.146(GND_49) AMC1.149(GND_50) AMC1.152(GND_51) AMC1.155(GND_52) AMC1.158(GND_53) AMC1.161(GND_54) AMC1.164(GND_55) AMC1.170(GND_56) B1.2(GND) B2.2(GND) B3.2(GND) B4.2(GND) B5.2(GND) B6.2(GND) B7.2(GND) C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.1 C13.2 C14.2 C15.2 C16.1 C17.2 C18.2 C19.2 C20.1 C21.1 C22.1 C23.1 C24.2 C25.1 C26.2 C27.2 C28.1 C29.2 C30.2 C31.2 C33.2 C34.1 C35.2 C36.1 C38.2 C39.2 C40.2 C41.2 C44.2 C46.2 C47.2 C48.2 C49.2 C51.2 C52.2 C54.1 C55.2 C57.1 C58.1 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.1 C74.1 C75.1 C76.1 C77.2 C78.2 C79.2 C80.2 C81.1 C82.2 C85.2 C86.2 C87.2 C88.1 C89.2 C90.1 C91.1 C92.1 C93.1 C96.1 C97.2 C98.2 C99.2 C102.2 C103.2 C105.2 C106.2 C112.2 C113.2 C114.2 C120.2 C121.2 C122.2 C124.2 C125.2 C128.2 C130.2 C131.2 C137.2 C138.2 C139.2 C140.2 C142.2 C144.2 C147.2 C148.2 C149.2 C150.2 C151.2 C152.2 C154.2 C155.2 C156.2 C164.2 C166.1 C167.1 C168.2 C169.2 C170.1 C171.1 C172.1 C173.1 C174.2 C175.2 C177.2 C178.1 C179.1 C180.1 C181.1 C182.1 C183.1 C184.1 C185.1 C188.2 C190.1 C191.2 C192.2 C193.2 C194.2 C195.2 C196.2 C197.2 C198.2 C199.1 C200.2 C201.2 C202.1 C203.2 C204.2 C205.2 C206.2 C207.2 C208.2 C209.2 C210.2 C211.2 C212.2 C213.1 C214.2 C215.2 C216.2 C217.2 C218.2 C219.2 C220.2 C221.2 C222.2 C223.2 C224.2 C225.2 C227.2 C229.2 C230.2 C231.2 C232.1 C234.2 C235.2 C236.2 C237.1 C243.2 C244.2 C247.2 C248.2 C249.2 C250.2 C251.2 C252.2 C257.2 C259.2 C260.2 C261.2 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C271.2 C272.2 C273.2 C274.2 C275.2 C276.2 C283.2 C285.2 C286.2 C287.2 C288.2 C289.2 C291.2 C293.2 C294.2 C295.2 C296.2 C297.2 C298.2 C299.2 C300.2 C303.2 C304.2 C305.2 C306.2 C307.2 C308.2 C309.2 C310.2 C311.2 C312.2 C313.1 C314.2 C315.2 C316.2 C317.2 C318.2 C319.2 C320.2 C321.2 C322.2 C323.2 C324.2 C325.2 C326.2 C327.1 C330.2 C331.2 C332.2 C333.2 C334.2 C335.2 C336.2 C337.2 C338.2 C339.2 C340.2 C341.1 C344.1 C345.2 C346.2 C347.2 C348.2 C349.2 C350.2 C351.2 C352.2 C353.2 C354.2 C355.2 C356.2 C357.2 C358.1 C359.2 C360.2 C361.2 C362.2 C363.2 C364.2 C365.2 C366.2 C367.2 C368.2 C369.2 C370.2 C371.1 C372.2 C373.2 C374.2 C375.2 C376.2 C377.2 C378.2 C379.2 C380.2 C381.2 C382.2 C383.2 C384.2 C385.2 C386.2 C387.2 C388.2 C389.2 C390.2 C391.1 C392.2 C393.2 C394.2 C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.2 C403.2 C404.2 C405.2 C406.2 C407.2 C408.2 C409.2 C410.1 C411.2 C412.2 C413.2 C414.2 C415.2 C416.2 C417.2 C418.2 C419.2 C420.2 C421.2 C422.2 C423.2 C424.2 C425.2 C426.2 C427.2 C428.2 C429.2 C430.2 C431.2 C432.2 C433.1 C435.2 C436.2 C437.2 C438.2 C439.2 C441.2 C442.1 C443.1 C444.1 C445.1 C446.1 C447.1 C448.2 C449.1 C450.1 C451.1 C452.1 C453.1 C454.2 C455.2 C458.1 C459.2 C460.1 C461.1 C464.1 C465.1 C466.1 C467.2 C468.2 C469.2 C470.2 C471.2 C472.2 C473.2 C474.2 C475.2 C476.2 C477.2 C478.2 C479.2 C480.2 C481.2 C482.2 C483.2 C484.2 C485.2 C486.2 C487.2 C488.2 C489.2 C490.2 C491.2 C492.2 C493.2 C494.2 C495.2 C496.2 C497.2 C498.2 C499.2 C500.2 C501.2 C502.2 C503.2 C504.2 C505.2 C507.2 C508.2 C509.2 C510.2 C511.2 C512.2 C513.2 C514.2 C515.2 C516.2 C517.2 C518.2 C519.2 C520.2 C521.2 C522.2 C523.2 C524.2 C525.2 C526.2 C527.2 C528.2 C529.2 C530.1 C531.2 C533.2 C534.2 C535.2 C536.2 C537.2 C538.2 C539.2 C540.2 C541.2 C542.2 C543.2 C544.2 C545.2 C546.2 C547.2 C548.2 C549.2 C550.2 C551.2 C552.2 C553.2 C554.2 C555.2 C556.2 C557.2 C558.2 C559.2 C560.2 C561.2 C562.2 C563.1 C564.2 C565.2 C566.2 C567.2 C568.2 C569.2 C570.2 C571.2 C572.2 C574.2 C575.2 C576.2 C577.2 C578.2 C579.2 C580.2 C581.2 C582.2 C583.2 C584.2 C586.2 C587.2 C588.2 C589.2 C590.2 C591.2 C592.2 C593.2 C594.2 C595.2 C596.2 C597.2 C598.2 C600.2 C601.2 C602.2 C603.1 C604.1 C605.1 C606.1 C608.2 C609.2 C611.2 C612.2 C613.2 C614.2 C615.2 C616.2 C617.2 C618.2 C619.2 C620.2 C621.2 C622.2 C623.2 C624.2 C625.2 C626.2 C627.2 C628.2 C629.2 C630.2 C631.2 C632.1 C633.2 C635.2 C636.2 C637.2 C638.2 C639.2 C640.2 C641.2 C642.2 C643.2 C644.2 C645.2 C646.2 C647.2 C648.2 C650.2 C651.2 C652.2 C653.2 C654.2 C655.2 C656.2 C657.2 C658.2 C659.2 C660.1 C661.2 C663.2 C664.2 C665.2 C666.2 C667.2 C668.2 C669.2 C670.2 C671.2 C672.2 C674.2 C675.2 C676.2 C677.2 C678.2 C679.2 C680.2 C682.2 C683.1 C684.2 C685.2 C686.2 C687.2 C688.2 C689.2 C690.2 C691.2 C692.2 C693.2 C694.2 C695.2 C696.2 C697.2 C698.2 C699.2 C700.2 C701.2 C702.2 C703.2 C704.2 C705.2 C706.2 C707.2 C708.2 C709.2 C710.2 C711.2 C712.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C727.2 C728.1 C729.2 C730.2 C731.2 C734.2 C735.2 C736.2 C737.2 C738.1 C739.2 C740.2 C741.2 C742.2 C743.1 C744.1 C745.1 C746.2 C747.2 C748.2 C749.2 C750.1 C751.1 C752.1 C753.1 C754.1 C755.2 C756.1 C757.1 C758.2 C759.2 C760.2 C761.2 C762.2 C763.2 C764.2 C765.2 C766.2 C767.2 C768.2 C772.2 C773.2 C774.2 C775.2 C776.2 C777.2 C778.2 C779.2 C780.2 C781.2 C783.1 C784.1 C785.2 C786.2 C787.2 C789.2 C790.1 C791.1 C792.2 C793.2 C794.2 C795.1 C796.2 C797.2 C798.2 C799.2 C800.2 C801.2 C802.1 C803.1 C804.1 C805.1 C806.2 C807.2 C808.2 C809.2 C810.2 C811.2 C812.2 C813.2 C814.2 C815.2 C818.2 C819.2 C824.2 C825.2 C826.2 C827.2 C828.2 C829.2 C830.2 C831.2 C832.2 C833.2 C834.2 C835.2 C836.2 C837.2 C838.2 C839.2 C840.2 C841.2 C842.2 C843.2 C844.1 C845.1 C846.2 C847.2 C849.2 C850.2 C855.2 C860.2 C861.2 C862.2 C863.2 C864.2 C865.2 C866.2 C872.1 C874.1 C875.2 C876.2 C881.2 C882.2 C883.2 C884.2 C885.2 C886.2 C887.2 C888.2 C889.2 C890.2 C891.2 C892.2 C893.2 C894.2 C895.2 C896.1 C899.2 CN1.3 CN3.3 CN3.5 CN3.9 CN4.2 CN6.3 CN7.3 CN7.4 CN7.57 CN7.58 CN7.63 CN7.64 CN7.117 CN7.118 CN7.H3(SMDFIX_1) CN7.H4(SMDFIX_2) CN7.H5(SMDFIX_3) CN7.H6(SMDFIX_4) CN7.H7(SMDFIX_5) CN7.H8(SMDFIX_6) CN7.H9(SMDFIX_7) CN7.H10(SMDFIX_8) CN7.H11(PTH_1) CN7.H12(PTH_2) COM1.2 COM2.2 CT1.2(NEGATIVE) CT2.2(NEGATIVE) CT3.2(NEGATIVE) CT4.2(NEGATIVE) CT5.2(NEGATIVE) CT6.2(NEGATIVE) CT7.2(NEGATIVE) CT8.2(NEGATIVE) D7.2(CATHODE) D10.2(T-) D12.1(ANODE) D15.1(ANODE) DIMM1.2(VSS1) DIMM1.3(VSS2) DIMM1.8(VSS3) DIMM1.9(VSS4) DIMM1.14(VSS5) DIMM1.17(VSS6) DIMM1.20(VSS7) DIMM1.23(VSS8) DIMM1.26(VSS9) DIMM1.29(VSS10) DIMM1.32(VSS11) DIMM1.35(VSS12) DIMM1.38(VSS13) DIMM1.41(VSS14) DIMM1.46(VSS15) DIMM1.47(VSS16) DIMM1.52(VSS17) DIMM1.53(VSS18) DIMM1.58(VSS19) DIMM1.61(VSS20) DIMM1.64(VSS21) DIMM1.67(VSS22) DIMM1.70(VSS23) DIMM1.73(VSS24) DIMM1.78(VSS25) DIMM1.79(VSS26) DIMM1.137(VSS27) DIMM1.138(VSS28) DIMM1.143(VSS29) DIMM1.146(VSS30) DIMM1.149(VSS31) DIMM1.152(VSS32) DIMM1.155(VSS33) DIMM1.158(VSS34) DIMM1.163(VSS35) DIMM1.164(VSS36) DIMM1.169(VSS37) DIMM1.170(VSS38) DIMM1.175(VSS39) DIMM1.178(VSS40) DIMM1.181(VSS41) DIMM1.184(VSS42) DIMM1.187(VSS43) DIMM1.190(VSS44) DIMM1.195(VSS45) DIMM1.196(VSS46) DIMM1.G1(PTH_1) DIMM1.G2(PTH_2) EEPROM1.4(VSS) EMU1.16 EMU1.57(PTH_61) EMU1.H3(PTH_1) EMU1.H4(PTH_2) EMU1.H5(PTH_3) EMU1.H6(PTH_4) FAN1.1 FB3.2 FB6.2 FB8.1 FB12.1 FB13.2 FB15.2 FB16.1 FB17.2 FB17.4 FB18.2 FB18.4 FB19.2 FB19.4 GND1.1 GND2.1 GND3.1 GND4.1 GNDC.1 J1.4(GND_1) J1.5(GND_2) J2.GA1(GNDA1) J2.GA2(GNDA2) J2.GA3(GNDA3) J2.GA4(GNDA4) J2.GA5(GNDA5) J2.GA6(GNDA6) J2.GA7(GNDA7) J2.GA8(GNDA8) J2.GA9(GNDA9) J2.GA10(GNDA10) J2.GB1(GNDB1) J2.GB2(GNDB2) J2.GB3(GNDB3) J2.GB4(GNDB4) J2.GB5(GNDB5) J2.GB6(GNDB6) J2.GB7(GNDB7) J2.GB8(GNDB8) J2.GB9(GNDB9) J2.GB10(GNDB10) J2.GC1(GNDC1) J2.GC2(GNDC2) J2.GC3(GNDC3) J2.GC4(GNDC4) J2.GC5(GNDC5) J2.GC6(GNDC6) J2.GC7(GNDC7) J2.GC8(GNDC8) J2.GC9(GNDC9) J2.GC10(GNDC10) J2.GD1(GNDD1) J2.GD2(GNDD2) J2.GD3(GNDD3) J2.GD4(GNDD4) J2.GD5(GNDD5) J2.GD6(GNDD6) J2.GD7(GNDD7) J2.GD8(GNDD8) J2.GD9(GNDD9) J2.GD10(GNDD10) J2.GE1(GNDE1) J2.GE2(GNDE2) J2.GE3(GNDE3) J2.GE4(GNDE4) J2.GE5(GNDE5) J2.GE6(GNDE6) J2.GE7(GNDE7) J2.GE8(GNDE8) J2.GE9(GNDE9) J2.GE10(GNDE10) J2.GF1(GNDF1) J2.GF2(GNDF2) J2.GF3(GNDF3) J2.GF4(GNDF4) J2.GF5(GNDF5) J2.GF6(GNDF6) J2.GF7(GNDF7) J2.GF8(GNDF8) J2.GF9(GNDF9) J2.GF10(GNDF10) J2.GG1(GNDG1) J2.GG2(GNDG2) J2.GG3(GNDG3) J2.GG4(GNDG4) J2.GG5(GNDG5) J2.GG6(GNDG6) J2.GG7(GNDG7) J2.GG8(GNDG8) J2.GG9(GNDG9) J2.GG10(GNDG10) J2.GH1(GNDH1) J2.GH2(GNDH2) J2.GH3(GNDH3) J2.GH4(GNDH4) J2.GH5(GNDH5) J2.GH6(GNDH6) J2.GH7(GNDH7) J2.GH8(GNDH8) J2.GH9(GNDH9) J2.GH10(GNDH10) J3.5(GND_2) J4.GA1(GNDA1) J4.GA2(GNDA2) J4.GA3(GNDA3) J4.GA4(GNDA4) J4.GA5(GNDA5) J4.GA6(GNDA6) J4.GA7(GNDA7) J4.GA8(GNDA8) J4.GA9(GNDA9) J4.GA10(GNDA10) J4.GB1(GNDB1) J4.GB2(GNDB2) J4.GB3(GNDB3) J4.GB4(GNDB4) J4.GB5(GNDB5) J4.GB6(GNDB6) J4.GB7(GNDB7) J4.GB8(GNDB8) J4.GB9(GNDB9) J4.GB10(GNDB10) J4.GC1(GNDC1) J4.GC2(GNDC2) J4.GC3(GNDC3) J4.GC4(GNDC4) J4.GC5(GNDC5) J4.GC6(GNDC6) J4.GC7(GNDC7) J4.GC8(GNDC8) J4.GC9(GNDC9) J4.GC10(GNDC10) J4.GD1(GNDD1) J4.GD2(GNDD2) J4.GD3(GNDD3) J4.GD4(GNDD4) J4.GD5(GNDD5) J4.GD6(GNDD6) J4.GD7(GNDD7) J4.GD8(GNDD8) J4.GD9(GNDD9) J4.GD10(GNDD10) J4.GE1(GNDE1) J4.GE2(GNDE2) J4.GE3(GNDE3) J4.GE4(GNDE4) J4.GE5(GNDE5) J4.GE6(GNDE6) J4.GE7(GNDE7) J4.GE8(GNDE8) J4.GE9(GNDE9) J4.GE10(GNDE10) J4.GF1(GNDF1) J4.GF2(GNDF2) J4.GF3(GNDF3) J4.GF4(GNDF4) J4.GF5(GNDF5) J4.GF6(GNDF6) J4.GF7(GNDF7) J4.GF8(GNDF8) J4.GF9(GNDF9) J4.GF10(GNDF10) J4.GG1(GNDG1) J4.GG2(GNDG2) J4.GG3(GNDG3) J4.GG4(GNDG4) J4.GG5(GNDG5) J4.GG6(GNDG6) J4.GG7(GNDG7) J4.GG8(GNDG8) J4.GG9(GNDG9) J4.GG10(GNDG10) J4.GH1(GNDH1) J4.GH2(GNDH2) J4.GH3(GNDH3) J4.GH4(GNDH4) J4.GH5(GNDH5) J4.GH6(GNDH6) J4.GH7(GNDH7) J4.GH8(GNDH8) J4.GH9(GNDH9) J4.GH10(GNDH10) J5.4 J5.8 J5.10 J5.12 J6.5(GND) J6.8(GND_DRAIN) J7.4(GND) J7.7(GND_DRAIN) J8.2 J8.3 J10.1(GND[0]) J10.4(GND[1]) J10.7(GND[2]) J11.2 J11.3 LCD1.11(VSS) LCD1.K(LED-) NOR1.10(VSS) OSC1.2(GND) PMBUS1.5 Q1.2(GND) Q2.1(ADJ/GND) Q3.2(E) Q4.2(E) Q5.2(E) Q6.2(E) Q7.2(S) Q8.2(S) Q10.3(ANODE) Q11.2(E) Q12.2(E) Q13.2(E) Q14.2(E) Q15.4(GND) Q15.9(EPAD) R2.2 R3.1 R4.1 R15.1 R33.2 R68.1 R76.2 R77.2 R78.2 R87.2 R95.1 R99.1 R103.2 R104.2 R108.1 R111.1 R112.1 R126.1 R135.1 R137.2 R138.1 R139.2 R142.1 R149.1 R150.1 R151.1 R153.1 R155.2 R159.1 R162.2 R175.1 R176.1 R180.1 R196.2 R199.1 R209.2 R212.1 R216.1 R218.2 R230.2 R231.2 R238.2 R240.1 R241.1 R243.2 R247.2 R250.2 R253.2 R260.1 R261.1 R269.1 R270.1 R281.1 R284.1 R286.1 R288.1 R291.1 R293.2 R294.2 R295.2 R296.2 R308.2 R320.1 R321.1 R325.1 R327.1 R330.1 R332.2 R341.2 R344.1 R347.1 R348.2 R351.2 R356.1 R358.2 R384.1 R385.1 R386.1 R417.2 R421.1 R429.1 R431.1 R432.1 R434.1 R436.1 R438.1 R439.2 R441.1 R442.2 R444.2 R445.2 R446.1 R449.2 R450.1 R453.1 R454.2 R458.1 R460.2 R462.2 R464.2 R465.2 R467.2 R469.2 R472.2 R478.2 R479.2 R488.2 R500.2 R507.2 R509.2 R514.2 R515.2 R522.2 R529.1 R530.2 R546.1 R550.1 R551.2 R552.2 R559.2 R562.2 R563.2 R564.2 R568.2 R569.2 R571.2 R572.2 R576.2 R585.2 R588.1 R590.1 R604.1 R605.1 R606.1 R607.1 R608.1 R609.1 R610.1 R612.1 R642.1 R648.2 R650.1 R652.2 R654.2 R655.1 R657.2 R658.1 R659.1 R661.1 R664.1 R665.1 R669.1 R671.1 RST_ATTN1.2 RST_BMC1.1 RST_PWR1.2 RV1.1 TP7.1 TP14.1 TP24.1 TP38.1 TP40.1 TP41.1 TP48.1 TP52.1 TP62.1 TP98.1 U1.4(GNDA) U1.9(GND_1) U1.21(GND_2) U1.33(GND_9) U1.45(GND_3) U1.54(GND_8) U1.57(GND_4) U1.69(GND_5) U1.82(GND_6) U1.94(GND_7) U2.2(GND) U2.25(DAP) U3.4(GND) U4.32(DVSS) U4.49(THERMAL_PAD) U4.50(THERMAL_VIA1) U4.51(THERMAL_VIA2) U4.52(THERMAL_VIA3) U4.53(THERMAL_VIA4) U4.54(THERMAL_VIA5) U4.55(THERMAL_VIA6) U4.56(THERMAL_VIA7) U4.57(THERMAL_VIA8) U4.58(THERMAL_VIA9) U4.59(THERMAL_VIA10) U4.60(THERMAL_VIA11) U4.61(THERMAL_VIA12) U4.62(THERMAL_VIA13) U4.63(THERMAL_VIA14) U4.64(THERMAL_VIA15) U4.65(THERMAL_VIA16) U4.66(THERMAL_VIA17) U4.67(THERMAL_VIA18) U4.68(THERMAL_VIA19) U4.69(THERMAL_VIA20) U4.70(THERMAL_VIA21) U4.71(THERMAL_VIA22) U4.72(THERMAL_VIA23) U4.73(THERMAL_VIA24) U4.74(THERMAL_VIA25) U5.4(GND) U6.10(GND) U6.21(EPAD) U7.8(GND) U7.17(EPAD) U8.10(VSS) U8.15(A0) U8.16(A1) U8.17(A2) U9.4(GND1) U9.17(GND2) U9.25(GND3) U10.10(GND) U10.21(EPAD) U11.7(GND) U12.3(GND) U13.2(GND) U14.10(GND) U14.21(E-PAD_1) U14.22(E-PAD_2) U14.23(E-PAD_3) U14.24(E-PAD_4) U14.25(E-PAD_5) U14.26(E-PAD_6) U14.27(E-PAD_7) U15.A19(VSS.1) U15.H1(SATA_VSS.1) U15.H2(SATA_VSS.2) U15.H8(VSS.2) U15.H9(VSS.3) U15.H15(VSS.4) U15.J7(VSS.5) U15.J8(VSS.6) U15.J9(VSS.7) U15.J10(VSS.8) U15.J11(VSS.9) U15.K1(SATA_VSS.3) U15.K2(SATA_VSS.4) U15.K7(VSS.10) U15.K8(VSS.11) U15.K9(VSS.12) U15.K10(VSS.13) U15.K11(VSS.14) U15.L3(SATA_VSS.5) U15.L5(VSS.15) U15.L7(VSS.16) U15.L8(VSS.17) U15.L9(VSS.18) U15.L10(VSS.19) U15.L11(VSS.20) U15.M1(SATA_VSS.6) U15.M4(VSS.21) U15.M5(VSS.22) U15.M6(VSS.23) U15.M7(VSS.24) U15.M10(VSS.25) U15.M11(VSS.26) U15.N5(VSS.27) U15.N11(VSS.28) U15.N12(VSS.29) U15.P11(VSS.30) U16.10(GND) U16.21(E-PAD_1) U16.22(E-PAD_2) U16.23(E-PAD_3) U16.24(E-PAD_4) U16.25(E-PAD_5) U16.26(E-PAD_6) U16.27(E-PAD_7) U17.49(GND_EPAD) U17.50(THERMAL_VIA_1) U17.51(THERMAL_VIA_2) U17.52(THERMAL_VIA_3) U17.53(THERMAL_VIA_4) U17.54(THERMAL_VIA_5) U17.55(THERMAL_VIA_6) U17.56(THERMAL_VIA_7) U17.57(THERMAL_VIA_8) U17.58(THERMAL_VIA_9) U17.59(THERMAL_VIA_10) U17.60(THERMAL_VIA_11) U17.61(THERMAL_VIA_12) U17.62(THERMAL_VIA_13) U17.63(THERMAL_VIA_14) U17.64(THERMAL_VIA_15) U17.65(THERMAL_VIA_16) U18.49(GND_EPAD) U18.50(THERMAL_VIA_1) U18.51(THERMAL_VIA_2) U18.52(THERMAL_VIA_3) U18.53(THERMAL_VIA_4) U18.54(THERMAL_VIA_5) U18.55(THERMAL_VIA_6) U18.56(THERMAL_VIA_7) U18.57(THERMAL_VIA_8) U18.58(THERMAL_VIA_9) U18.59(THERMAL_VIA_10) U18.60(THERMAL_VIA_11) U18.61(THERMAL_VIA_12) U18.62(THERMAL_VIA_13) U18.63(THERMAL_VIA_14) U18.64(THERMAL_VIA_15) U18.65(THERMAL_VIA_16) U19.2(GND) U20.4(PGND) U20.7(MODE) U20.10(AGND) U20.17(EPAD) U21.4(GND) U22.2(GND1) U22.3(GND2) U22.15(EPAD) U23.A1(VSS_1) U23.A33(VSS_2) U23.AA4(VSS_193) U23.AA7(VSS_194) U23.AA9(VSS_195) U23.AA11(VSS_196) U23.AA13(VSS_197) U23.AA15(VSS_198) U23.AA17(VSS_199) U23.AA19(VSS_200) U23.AA21(VSS_201) U23.AA23(VSS_202) U23.AA25(VSS_203) U23.AA27(VSS_204) U23.AA32(VSS_205) U23.AB8(VSS_206) U23.AB10(VSS_207) U23.AB12(VSS_208) U23.AB14(VSS_209) U23.AB16(VSS_210) U23.AB18(VSS_211) U23.AB20(VSS_212) U23.AB22(VSS_213) U23.AB24(VSS_214) U23.AB26(VSS_215) U23.AB28(VSS_216) U23.AC7(VSS_217) U23.AC9(VSS_218) U23.AC11(VSS_219) U23.AC13(VSS_220) U23.AC15(VSS_221) U23.AC17(VSS_222) U23.AC19(VSS_223) U23.AC21(VSS_224) U23.AC23(VSS_225) U23.AC25(VSS_226) U23.AC27(VSS_227) U23.AD5(VSS_228) U23.AD8(VSS_229) U23.AD10(VSS_230) U23.AD12(VSS_231) U23.AD14(VSS_232) U23.AD16(VSS_233) U23.AD18(VSS_234) U23.AD20(VSS_235) U23.AD22(VSS_236) U23.AD24(VSS_237) U23.AD26(VSS_238) U23.AD28(VSS_239) U23.AE9(VSS_240) U23.AE11(VSS_241) U23.AE13(VSS_242) U23.AE15(VSS_243) U23.AE17(VSS_244) U23.AE19(VSS_245) U23.AE21(VSS_246) U23.AE23(VSS_247) U23.AE25(VSS_248) U23.AE27(VSS_249) U23.AE32(VSS_250) U23.AF8(VSS_251) U23.AF10(VSS_252) U23.AF12(VSS_253) U23.AF14(VSS_254) U23.AF16(VSS_255) U23.AF18(VSS_256) U23.AF20(VSS_257) U23.AF22(VSS_258) U23.AF24(VSS_259) U23.AF26(VSS_260) U23.AF28(VSS_261) U23.AG7(VSS_262) U23.AG9(VSS_263) U23.AG11(VSS_264) U23.AG13(VSS_265) U23.AG15(VSS_266) U23.AG17(VSS_267) U23.AG19(VSS_268) U23.AG21(VSS_269) U23.AG23(VSS_270) U23.AG25(VSS_271) U23.AG27(VSS_272) U23.AH8(VSS_273) U23.AH10(VSS_274) U23.AH12(VSS_275) U23.AH14(VSS_276) U23.AH16(VSS_277) U23.AH18(VSS_278) U23.AH20(VSS_279) U23.AH22(VSS_280) U23.AH24(VSS_281) U23.AH26(VSS_282) U23.AH28(VSS_283) U23.AJ4(VSS_284) U23.AJ6(VSS_285) U23.AJ9(VSS_286) U23.AJ13(VSS_287) U23.AJ16(VSS_288) U23.AJ19(VSS_289) U23.AJ21(VSS_290) U23.AJ23(VSS_291) U23.AJ29(VSS_292) U23.AK3(VSS_293) U23.AK6(VSS_294) U23.AK9(VSS_295) U23.AK12(VSS_296) U23.AK15(VSS_297) U23.AK18(VSS_298) U23.AK21(VSS_299) U23.AK24(VSS_300) U23.AK27(VSS_301) U23.AK30(VSS_302) U23.AL4(VSS_303) U23.AL7(VSS_304) U23.AL10(VSS_305) U23.AL13(VSS_306) U23.AL16(VSS_307) U23.AL19(VSS_308) U23.AL22(VSS_309) U23.AL25(VSS_310) U23.AL28(VSS_311) U23.AL31(VSS_312) U23.AM1(VSS_313) U23.AM3(VSS_314) U23.AM6(VSS_315) U23.AM9(VSS_316) U23.AM12(VSS_317) U23.AM15(VSS_318) U23.AM18(VSS_319) U23.AM21(VSS_320) U23.AM24(VSS_321) U23.AM27(VSS_322) U23.AM30(VSS_323) U23.AN1(VSS_324) U23.AN2(VSS_325) U23.AN4(VSS_326) U23.AN7(VSS_327) U23.AN10(VSS_328) U23.AN13(VSS_329) U23.AN16(VSS_330) U23.AN19(VSS_331) U23.AN22(VSS_332) U23.AN25(VSS_333) U23.AN28(VSS_334) U23.AN31(VSS_335) U23.AN33(VSS_336) U23.C5(VSS_3) U23.C9(VSS_4) U23.C14(VSS_5) U23.C19(VSS_6) U23.C23(VSS_7) U23.C27(VSS_8) U23.C29(VSS_9) U23.D3(VSS_10) U23.D7(VSS_11) U23.D11(VSS_12) U23.D17(VSS_13) U23.D21(VSS_14) U23.D25(VSS_15) U23.D31(VSS_16) U23.F4(VSS_17) U23.F6(VSS_18) U23.F8(VSS_19) U23.F10(VSS_20) U23.F12(VSS_21) U23.F14(VSS_22) U23.F16(VSS_23) U23.F18(VSS_24) U23.F20(VSS_25) U23.F22(VSS_26) U23.F24(VSS_27) U23.F26(VSS_28) U23.F28(VSS_29) U23.F30(VSS_30) U23.G7(VSS_31) U23.G9(VSS_32) U23.G11(VSS_33) U23.G13(VSS_34) U23.G15(VSS_35) U23.G17(VSS_36) U23.G19(VSS_37) U23.G21(VSS_38) U23.G23(VSS_39) U23.G25(VSS_40) U23.G27(VSS_41) U23.G29(VSS_42) U23.G31(VSS_43) U23.H8(VSS_44) U23.H10(VSS_45) U23.H12(VSS_46) U23.H14(VSS_47) U23.H16(VSS_48) U23.H18(VSS_49) U23.H20(VSS_50) U23.H22(VSS_51) U23.H24(VSS_52) U23.H26(VSS_53) U23.H28(VSS_54) U23.J3(VSS_55) U23.J7(VSS_56) U23.J11(VSS_57) U23.J13(VSS_58) U23.J15(VSS_59) U23.J17(VSS_60) U23.J19(VSS_61) U23.J21(VSS_62) U23.J23(VSS_63) U23.J25(VSS_64) U23.J27(VSS_65) U23.K10(VSS_66) U23.K12(VSS_67) U23.K14(VSS_68) U23.K16(VSS_69) U23.K18(VSS_70) U23.K20(VSS_71) U23.K22(VSS_72) U23.K24(VSS_73) U23.K28(VSS_74) U23.L7(VSS_75) U23.L9(VSS_76) U23.L11(VSS_77) U23.L13(VSS_78) U23.L15(VSS_79) U23.L17(VSS_80) U23.L19(VSS_81) U23.L21(VSS_82) U23.L23(VSS_83) U23.L25(VSS_84) U23.L27(VSS_85) U23.M1(VSS_86) U23.M8(VSS_87) U23.M10(VSS_88) U23.M12(VSS_89) U23.M14(VSS_90) U23.M16(VSS_91) U23.M18(VSS_92) U23.M20(VSS_93) U23.M22(VSS_94) U23.M24(VSS_95) U23.M26(VSS_96) U23.M28(VSS_97) U23.N2(VSS_98) U23.N7(VSS_99) U23.N9(VSS_100) U23.N11(VSS_101) U23.N13(VSS_102) U23.N15(VSS_103) U23.N17(VSS_104) U23.N19(VSS_105) U23.N21(VSS_106) U23.N23(VSS_107) U23.N25(VSS_108) U23.N27(VSS_109) U23.N32(VSS_110) U23.P8(VSS_111) U23.P10(VSS_112) U23.P12(VSS_113) U23.P14(VSS_114) U23.P16(VSS_115) U23.P18(VSS_116) U23.P20(VSS_117) U23.P22(VSS_118) U23.P24(VSS_119) U23.P26(VSS_120) U23.P28(VSS_121) U23.R1(VSS_122) U23.R7(VSS_123) U23.R9(VSS_124) U23.R11(VSS_125) U23.R13(VSS_126) U23.R15(VSS_127) U23.R17(VSS_128) U23.R19(VSS_129) U23.R21(VSS_130) U23.R23(VSS_131) U23.R25(VSS_132) U23.R27(VSS_133) U23.T2(VSS_134) U23.T8(VSS_135) U23.T10(VSS_136) U23.T12(VSS_137) U23.T14(VSS_138) U23.T16(VSS_139) U23.T18(VSS_140) U23.T20(VSS_141) U23.T22(VSS_142) U23.T24(VSS_143) U23.T26(VSS_144) U23.T28(VSS_145) U23.U3(VSS_146) U23.U7(VSS_147) U23.U9(VSS_148) U23.U11(VSS_149) U23.U13(VSS_150) U23.U15(VSS_151) U23.U17(VSS_152) U23.U19(VSS_153) U23.U21(VSS_154) U23.U23(VSS_155) U23.U25(VSS_156) U23.U27(VSS_157) U23.U32(VSS_158) U23.V1(VSS_159) U23.V8(VSS_160) U23.V10(VSS_161) U23.V12(VSS_162) U23.V14(VSS_163) U23.V16(VSS_164) U23.V18(VSS_165) U23.V20(VSS_166) U23.V22(VSS_167) U23.V24(VSS_168) U23.V26(VSS_169) U23.V28(VSS_170) U23.W2(VSS_171) U23.W9(VSS_172) U23.W11(VSS_173) U23.W13(VSS_174) U23.W15(VSS_175) U23.W17(VSS_176) U23.W19(VSS_177) U23.W21(VSS_178) U23.W23(VSS_179) U23.W25(VSS_180) U23.W27(VSS_181) U23.Y8(VSS_182) U23.Y10(VSS_183) U23.Y12(VSS_184) U23.Y14(VSS_185) U23.Y16(VSS_186) U23.Y18(VSS_187) U23.Y20(VSS_188) U23.Y22(VSS_189) U23.Y24(VSS_190) U23.Y26(VSS_191) U23.Y28(VSS_192) U25.2(GND1) U25.3(GND2) U25.15(EPAD) U26.2(GND) U27.3 U28.B1(GND) U29.B1(GND) U31.3 U32.2(GND) U33.7(PGND1) U33.8(PGND2) U33.49(EPAD) U34.13(PGND1) U34.14(PGND2) U34.15(PGND3) U34.16(PGND4) U34.17(PGND5) U34.18(PGND6) U34.19(PGND7) U34.20(PGND8) U34.26(PGND9) U34.41(EPAD) U35.1(GND) U35.11(DAP) U36.2(GND) U37.2(GND) U38.8(GND1) U38.9(GND2) U38.14(2O\E\) U38.15(1O\E\) U39.10(VSS) U39.15(A0) U39.16(A1) U39.17(A2) U40.11(GND) U41.11(GND) U42.4(GND) U42.7(G\) U43.10(VSS) U43.15(A0) U43.16(A1) U43.17(A2) U44.10(VSS) U44.15(A0) U44.16(A1) U44.17(A2) U45.11(GND) U46.11(GND) U47.1(EN#) U47.14(GND) U48.7(GND) U49.8(GND) U49.17(EPAD) U50.1(EN#) U50.14(GND) U51.10(GND) U51.21(EPAD) U52.4(GND) U52.7(G\) U53.C5(VSS4) U53.F7(VSS1) U53.K3(VSS3) U53.K8(VSS2) U54.1(1OE#) U54.10(GND) U54.19(2OE#) U54.21(EPAD) U55.4(GND) U56.2(GND) U56.5(DIR) U57.10(GND) U58.2(GND) U59.3(GND) U61.5(A) U62.B1(GND) U63.B1(GND) U64.4(GND) U65.8(GND_1) U65.12(GND_2) U65.13(GND_3) U66.4(GND) U67.1(GND) U68.7(GND) U69.1(GND) U70.5(GND) U71.4(GND) U72.5(GND) U73.10(VDDO_SEL) U73.57(VSS) U74.4(PGND) U74.8(GND) U74.11(EPAD) U74.12(EPAD1) U74.13(EPAD2) U74.14(EPAD3) U74.15(EPAD4) U74.16(EPAD5) U75.20(VSS) U75.57(EPAD) U76.4(GND) U77.10(VDDO_SEL) U77.57(VSS) U78.A1(VSS1) U78.A3(VSSQ1) U78.B7(VSSQ2) U78.C3(VSSQ3) U78.D7(VSSQ4) U78.E3(VSS2) U78.J1(VSS3) U79.2(GND) U80.11(GND1) U80.12(GND2) U80.13(GND3) U80.25(TPAD) U81.3(GND) Y2.2 Y2.3 Y4.2(GND) Y5.2 Y5.4 Y6.2 Y6.4 Y7.2 Y7.4 Y8.2 Y8.4
GND_3: FB3.1 U4.36(AVSS1) U4.47(AVSS2)
GND_LAN: FB8.2 J9.10A(GND) J9.10B(GND) J9.SH1(P1_PTH_1) J9.SH2(P1_PTH_2) J9.SH3(P2_PTH_1) J9.SH4(P2_PTH_2)
GND_USB: D13.4(GND) FB13.1 J1.6(PTH1) J1.7(PTH2)
VBAT: C10.1 CN1.2 OSC1.1(OE) OSC1.4(VCC) U1.55(VBAT)
VBUS0: C164.1 R426.1 U29.A1(VOUT)
VBUS0_R: R426.2 U23.W5(USB0VBUS)
VBUS1: C151.1 R424.1 U28.A1(VOUT)
VBUS1_R: R424.2 U23.V4(USB1VBUS)
VCC0V75: C766.1 C767.1 C768.1 C803.2 C804.2 C805.2 C806.1 C807.1 C808.1 CT8.1(POSITIVE) DIMM1.203(VTT1) DIMM1.204(VTT2) R41.2 TP84.1 U74.3(VO) U74.5(VOSNS)
VCC0V75_EN: R12.2 R529.2 U74.7(EN)
VCC0V75_MON: R41.1 U4.45(MON8)
VCC0V75REF: C57.2 C120.1 C530.2 C531.1 C576.1 C758.1 C765.1 DIMM1.1(VREF_DQ) DIMM1.84(VREF_CA) U23.F15(DDRVREFSSTL) U74.6(REFOUT)
VCC0V85: C245.2 C248.1 C249.1 C250.1 C251.1 C441.1 C454.1 FB20.2 FB22.2 FB23.2 FB30.2 FB31.1 L10.2 R62.2 R256.1 UNK0V85.1
VCC0V85_EN: R337.2 R607.2 U33.34(ENSW4)
VCC0V85_MON: R62.1 U4.2(MON2)
VCC1V5: C121.1 C122.1 C124.1 C125.1 C130.1 C140.1 C147.1 C155.1 C472.1 C475.1 C480.1 C487.1 C488.1 C507.1 C510.1 C519.1 C533.1 C536.1 C552.1 C553.1 C564.1 C565.1 C574.1 C577.1 C595.1 C600.1 C601.1 C602.1 C611.1 C612.1 C613.1 C622.1 C636.1 C637.1 C638.1 C663.1 C664.1 C671.1 C682.1 C684.1 C685.1 C691.1 C697.1 C705.1 C706.1 C713.1 C720.1 C721.1 C723.1 C779.1 C780.1 DIMM1.85(VDD1) DIMM1.86(VDD2) DIMM1.93(VDD3) DIMM1.94(VDD4) DIMM1.101(VDD5) DIMM1.102(VDD6) DIMM1.109(VDD7) DIMM1.110(VDD8) DIMM1.115(VDD9) DIMM1.116(VDD10) DIMM1.123(VDD11) DIMM1.124(VDD12) DIMM1.131(VDD13) DIMM1.132(VDD14) L2.2 R29.2 R204.1 R549.1 TP44.1 U23.A2(DVDD15_1) U23.A32(DVDD15_2) U23.B1(DVDD15_3) U23.B33(DVDD15_4) U23.C3(DVDD15_5) U23.C7(DVDD15_6) U23.C11(DVDD15_7) U23.C17(DVDD15_8) U23.C21(DVDD15_9) U23.C25(DVDD15_10) U23.C31(DVDD15_11) U23.D5(DVDD15_12) U23.D9(DVDD15_13) U23.D14(DVDD15_14) U23.D19(DVDD15_15) U23.D23(DVDD15_16) U23.D27(DVDD15_17) U23.D29(DVDD15_18) U23.F5(DVDD15_19) U23.F7(DVDD15_20) U23.F9(DVDD15_21) U23.F11(DVDD15_22) U23.F13(DVDD15_23) U23.F17(DVDD15_24) U23.F19(DVDD15_25) U23.F21(DVDD15_26) U23.F23(DVDD15_27) U23.F25(DVDD15_28) U23.F27(DVDD15_29) U23.F29(DVDD15_30) U23.G10(DVDD15_31) U23.G14(DVDD15_32) U23.G20(DVDD15_33) U23.G26(DVDD15_34) U23.G28(DVDD15_35) U23.G30(DVDD15_36) U23.H7(DVDD15_37) U23.H9(DVDD15_38) U23.H11(DVDD15_39) U23.H13(DVDD15_40) U23.H15(DVDD15_41) U23.H17(DVDD15_42) U23.H19(DVDD15_43) U23.H21(DVDD15_44) U23.H23(DVDD15_45) U23.H25(DVDD15_46) U23.H27(DVDD15_47) U74.2(VLDOIN)
VCC1V5_EN: R56.2 R610.2 U22.10(EN)
VCC1V5_MON: R29.1 U4.42(MON7)
VCC1V8: C15.1 C19.1 C20.2 C21.2 C22.2 C23.2 C24.1 C25.2 C26.1 C27.1 C28.2 C29.1 C30.1 C97.1 C156.1 C194.1 C215.1 C216.1 C285.1 C286.1 C287.1 C288.1 C292.2 C311.1 C316.1 C317.1 C320.1 C321.1 C330.1 C333.1 C334.1 C335.1 C355.1 C357.1 C368.1 C371.2 C374.1 C391.2 C417.1 C468.1 C470.1 C471.1 C473.1 C474.1 C476.1 C479.1 C483.1 C484.1 C485.1 C489.1 C496.1 C497.1 C500.1 C501.1 C502.1 C516.1 C518.1 C635.1 C650.1 C696.1 C703.1 C704.1 C707.1 C708.1 C709.1 C710.1 C711.1 C712.1 C714.1 C715.1 C716.1 C717.1 C718.1 C719.1 C722.1 C725.1 C729.1 C730.1 C736.1 C746.1 C749.1 C760.1 C761.1 C875.1 C893.1 CN7.1 CN7.2 EEPROM1.8(VCC) FB7.1 FB9.1 FB10.1 FB11.1 FB21.2 FB24.2 FB26.2 FB28.2 FB29.2 FB33.1 FB34.1 L13.2 NOR1.2(VCC) Q9.2(EMITTER) R31.2 R44.2 R45.1 R53.2 R64.2 R66.2 R74.2 R88.2 R109.2 R127.2 R182.2 R183.2 R184.2 R197.1 R200.1 R239.2 R242.2 R244.2 R274.1 R317.2 R323.2 R329.2 R357.1 R378.2 R390.2 R418.2 R422.2 R423.1 R425.2 R428.1 R435.1 R440.1 R443.1 R468.1 R470.1 R474.1 R475.2 R480.1 R491.1 R494.1 R506.1 R528.2 R536.2 R537.2 R553.2 R555.2 R579.2 R626.2 R627.2 U6.20(VCC) U10.20(VCC) U11.1(VCCA) U13.5(VCC) U14.20(VCC) U16.20(VCC) U21.1(VCCA) U23.AA3(DVDD18_24) U23.AA8(DVDD18_25) U23.AA28(DVDD18_26) U23.AA31(DVDD18_27) U23.AB7(DVDD18_28) U23.AB27(DVDD18_29) U23.AC8(DVDD18_30) U23.AC28(DVDD18_31) U23.AD4(DVDD18_32) U23.AD27(DVDD18_33) U23.AE8(DVDD18_34) U23.AE26(DVDD18_35) U23.AE28(DVDD18_36) U23.AE31(DVDD18_37) U23.AF27(DVDD18_38) U23.AG26(DVDD18_39) U23.AH27(DVDD18_40) U23.AJ30(DVDD18_41) U23.AM33(DVDD18_42) U23.AN32(DVDD18_43) U23.J2(DVDD18_1) U23.J28(DVDD18_2) U23.K27(DVDD18_3) U23.L8(DVDD18_4) U23.L28(DVDD18_5) U23.M2(DVDD18_6) U23.M7(DVDD18_7) U23.M27(DVDD18_8) U23.N8(DVDD18_9) U23.N28(DVDD18_10) U23.N31(DVDD18_11) U23.P7(DVDD18_12) U23.P27(DVDD18_13) U23.R28(DVDD18_14) U23.T7(DVDD18_15) U23.T27(DVDD18_16) U23.U28(DVDD18_17) U23.U31(DVDD18_18) U23.V7(DVDD18_19) U23.V27(DVDD18_20) U23.W28(DVDD18_21) U23.Y7(DVDD18_22) U23.Y27(DVDD18_23) U27.5 U31.5 U37.3(VCCA) U37.7(VCCB) U38.16(VCCB) U39.9(VDD) U40.2(VCCA) U40.19(VCCB) U41.2(VCCA) U43.9(VDD) U44.9(VDD) U45.2(VCCA) U46.2(VCCA) U46.19(VCCB) U48.14(VCC) U51.20(VCC) U53.D3(VCC2) U53.G4(VCC1) U53.H8(VCC3) U53.J6(VCC4) U54.20(VCC) U55.8(VCC) U56.1(VCCA) U57.20(VCC) U58.3(VCCA) U63.A2(VIN) U64.1(VCCA) U67.2(VREF1) U68.1(VCCA) U69.2(VREF1) U70.8(VDDO) U71.1(VCCA) U72.8(VDDO) U75.7(VDDIO_1) U75.52(VDDIO_2) U79.3(VCCA) U80.23(VCCB#23) U80.24(VCCB#24) UNK1V8.1
VCC1V8_EN: R26.2 R606.2 U33.27(ENSW3)
VCC1V8_MON: R323.1 U4.41(MON6)
VCC1V8_TCT: C815.1 FB34.2 R556.2 R570.2
VCC2V5: C423.1 C883.1 C884.1 C885.1 C886.1 C887.1 C888.1 C889.1 C890.1 C891.1 C892.1 C894.1 J9.11A(P1_COMMON1) J9.11B(P2_COMMON1) J9.13A(P1_COMMON2) J9.13B(P2_COMMON2) Q15.1(VOUT) R624.2 R625.2 R647.1 TP95.1 U58.7(VCCB) U73.11(VDDO_1) U73.49(VDDO_2) U73.52(VDDO_3) U77.11(VDDO_1) U77.49(VDDO_2) U77.52(VDDO_3) U80.1(VCCA)
VCC2V5_EN: C895.1 Q15.5(EN) R649.2 R650.2
VCC3_AUX_MON: R21.1 R321.2 U4.39(MON4)
VCC3_LCD: C304.1 LCD1.12(VDD) Q10.2(CATHODE) R306.2 R309.2
VCC3_LCDBK: LCD1.A(LED+) R310.1
VCC3V3_AUX: B1.1(IN) B2.1(IN) B3.1(IN) B4.1(IN) B5.1(IN) B6.1(IN) B7.1(IN) C31.1 C35.1 C98.1 C289.1 C290.2 C291.1 C293.1 C294.1 C296.1 C332.1 C348.1 C351.1 C352.1 C353.1 C356.1 C361.1 C455.1 C633.1 C731.1 C737.1 C747.1 C762.1 C772.1 C775.1 C789.1 C790.2 C796.1 C835.1 C876.1 C881.1 C882.1 CN7.61 CN7.62 CN7.119 CN7.120 DIMM1.199(VDDSPD) FB32.1 FB35.1 L14.2 Q15.8(VIN) R21.2 R35.2 R69.2 R71.2 R73.2 R89.2 R100.2 R113.1 R136.2 R161.1 R188.2 R193.2 R198.2 R201.2 R213.2 R215.2 R251.2 R252.2 R273.1 R276.2 R310.2 R339.1 R359.1 R361.1 R377.2 R463.2 R482.1 R493.2 R496.2 R497.2 R508.2 R513.1 R532.2 R557.2 R578.2 R581.2 R591.2 R595.2 R611.2 R614.1 R615.2 U7.16(VCC) U11.14(VCCB) U12.5(VCC) U21.8(VCCB) U35.3(VDD) U45.19(VCCB) U49.16(VCC) U50.15(VCC) U52.8(VCC) U56.6(VCCB) U62.A2(VIN) U68.14(VCCB) U70.1(VDD) U71.8(VCCB) U72.1(VDD) U74.10(VIN) U76.3(WP#) U76.7(HOLD#) U76.8(VCC) U79.7(VCCB) UNK3V3.1 Y4.1(EN) Y4.4(VCC)
VCC3V3_AUX_EN: R336.2 R605.2 R649.1 U33.13(ENSW2)
VCC3V3_AUX_F1: B5.3(OUT) C397.1 C403.1 C405.1 C412.1 C413.1 C415.1 C419.1 C425.1 C426.1 C427.1 C428.1 R601.2 R602.2 U17.7(VDD_PRI_REF) U17.10(VDD_SEC_REF) U17.13(VDD_Y0_Y1_1) U17.18(VDD_Y0_Y1_2) U17.19(VDD_Y2_Y3_1) U17.24(VDD_Y2_Y3_2) U17.27(VDD_Y4) U17.30(VDD_Y5) U17.31(VDD_Y6) U17.34(VDD_Y7) U17.48(DVDD)
VCC3V3_AUX_F2: B6.3(OUT) C401.1 C404.1 C406.1 C411.1 C414.1 C416.1 C420.1 C429.1 C430.1 C431.1 C432.1 U18.7(VDD_PRI_REF) U18.10(VDD_SEC_REF) U18.13(VDD_Y0_Y1_1) U18.18(VDD_Y0_Y1_2) U18.19(VDD_Y2_Y3_1) U18.24(VDD_Y2_Y3_2) U18.27(VDD_Y4) U18.30(VDD_Y5) U18.31(VDD_Y6) U18.34(VDD_Y7) U18.48(DVDD)
VCC3V3_EN: R55.2 R665.2 U62.B2(ON)
VCC3V3_MP: C1.1 C2.1 C11.1 C297.1 C303.1 C312.1 C314.1 C315.1 C319.1 C323.1 C325.1 C331.1 C336.1 C337.1 C339.1 C340.1 C515.1 C541.1 C542.1 C899.1 D1.1(CATHODE) D2.1(CATHODE) FB1.2 Q1.4(VDD) R5.2 R8.2 R9.2 R10.1 R13.1 R14.1 R28.1 R32.2 R38.2 R47.2 R179.2 R205.2 R298.2 R299.2 R305.2 R306.1 R307.1 R311.1 R313.1 R314.1 R315.1 R316.1 R322.1 R326.1 R334.1 R335.1 R338.1 R360.2 R459.1 R466.1 R656.2 U1.3(VDDA) U1.8(VDD_1) U1.20(VDD_2) U1.32(VDD_3) U1.44(VDD_4) U1.56(VDD_5) U1.68(VDD_6) U1.81(VDD_7) U1.93(VDD_8) U3.8(VCC) U4.33(V33D) U8.9(VDD) U36.5(VCC) U38.1(VCCA) U38.2(1DIR) U38.3(2DIR) U41.19(VCCB) U42.8(VCC) U47.15(VCC) U64.8(VCCB) U66.1(VCCA) U66.8(VCCB) U81.5(VCC)
VCC3V3_MP_ALT: C5.1 D1.2(ANODE) Q2.2(VOUT1) Q2.4(VOUT2) R292.1 TP8.1
VCC3V3_MP_ALT_DET: R291.2 R292.2 U1.99(PD6)
VCC3V3_MP_AMC: AMC1.4(MP) D2.2(ANODE) R190.2
VCC3V3_PCIE: B7.3(OUT) C492.1 C493.1 C494.1 C584.1 C594.1 R451.1 U65.1(VDD_1) U65.10(VDD_2) U65.11(VDD_3)
VCC5_MON: R18.1 R320.2 U4.38(MON3)
VCC5V: C128.1 C131.1 C154.1 C777.1 C824.1 C825.1 C826.1 C828.1 CN7.59 CN7.60 J8.4 L6.2 R18.2 R219.2 R222.2 R245.2 TP50.1 U26.5(IN) U32.5(IN)
VCC5V_EN: R60.2 R609.2 U25.10(EN)
VCC12: C275.1 C797.1 C812.1 C813.1 C814.1 CT7.1(POSITIVE) D12.2(CATHODE) F1.2 FAN1.2 FB2.1 FB36.1 FB37.1 FB38.1 FB39.1 J4.A1(PWRA1) J4.A2(PWRA2) J4.B1(PWRB1) J4.B2(PWRB2) J8.1 R254.1 R267.2 TP61.1
VCC12_AMC: AMC1.2(PWR_12V_1) AMC1.9(PWR_12V_2) AMC1.18(PWR_12V_3) AMC1.27(PWR_12V_4) AMC1.42(PWR_12V_5) AMC1.57(PWR_12V_6) AMC1.72(PWR_12V_7) AMC1.84(PWR_12V_8) F1.1 J11.1
VCCPLLA1A: B3.3(OUT) C41.1 C49.1 U18.37(VDD_PLL1)
VCCPLLA1B: B4.3(OUT) C38.1 C47.1 U18.38(VDD_PLL2) U18.39(VDD_VCO)
VCCPLLA2A: B1.3(OUT) C39.1 C48.1 U17.37(VDD_PLL1)
VCCPLLA2B: B2.3(OUT) C40.1 C46.1 U17.38(VDD_PLL2) U17.39(VDD_VCO)
VDD33: C443.2 C453.2 C467.1 C469.1 C517.1 C537.1 C539.1 C545.1 C557.1 FB25.2 FB27.2 R172.1 TP39.1 U23.P11(USB1DVDD33) U23.Y11(USB0DVDD33) U62.A1(VOUT)
VDD_USB_0: C528.1 C529.1 FB20.1 U23.U10(VDDUSB0_1) U23.V11(VDDUSB0_2)
VDD_USB_1: C538.1 C546.1 FB30.1 U23.R12(VDDUSB1_1) U23.T11(VDDUSB1_2)
VDDA: C853.2 U33.19(VDDA)
VDDAHV: C540.1 C561.1 C583.1 C598.1 C620.1 C621.1 C647.1 C648.1 C670.1 C695.1 FB29.1 U23.AH11(VDDAHV1) U23.AH13(VDDAHV2) U23.AH15(VDDAHV3) U23.AH17(VDDAHV4) U23.AH19(VDDAHV5) U23.AH21(VDDAHV6) U23.AH23(VDDAHV7) U23.AH25(VDDAHV8)
VDDALV: C514.1 C527.1 C550.1 C560.1 C572.1 C592.1 C593.1 C609.1 C630.1 C631.1 C646.1 C659.1 C669.1 C680.1 FB31.2 U23.AE10(VDDALV1) U23.AE12(VDDALV2) U23.AE14(VDDALV3) U23.AE16(VDDALV4) U23.AE18(VDDALV5) U23.AE20(VDDALV6) U23.AE22(VDDALV7) U23.AE24(VDDALV8) U23.AF9(VDDALV9) U23.AF11(VDDALV10) U23.AF13(VDDALV11) U23.AF15(VDDALV12) U23.AF17(VDDALV13) U23.AF19(VDDALV14) U23.AF21(VDDALV15) U23.AF23(VDDALV16) U23.AF25(VDDALV17) U23.AG16(VDDALV18) U23.AG18(VDDALV19) U23.AG20(VDDALV20) U23.AG22(VDDALV21) U23.AG24(VDDALV22)
VDDCMON: C520.1 R545.1 TP86.1 U23.J10(CVDDCMON)
VDDCMON_R: R544.1 R545.2 U34.31(VOUTS+)
VDDD: C852.2 R272.1 R282.1 R567.1 U33.20(VDDD)
VDDG: C854.2 U33.18(VDDG)
VDDPLL0: C495.1 C551.1 C562.1 C586.1 C651.1 C674.1 FB28.1 U23.E14(AVDDA7) U23.G8(AVDDA6) U23.G16(AVDDA8) U23.G22(AVDDA9) U23.G24(AVDDA10)
VSS_RTC: C32.1 C37.1 U15.H18(VSS_RTC)
VSSCMON: C503.1 R547.1 TP93.1 U23.J9(VSSCMON)
VSSCMON_R: R546.2 R547.2 U34.32(VOUTS-)
25M_CLK_REFN: R167.2 U18.12(SEC_REFN)
25M_CLK_REFP: R163.2 R164.2 U18.11(SEC_REFP)
25M_SEC_REFN: R177.1 U18.25(Y4_N)
25M_SEC_REFP: R178.1 U18.26(Y4_P)
9090FPWM4: CN5.1 U4.13(FPWM4/GPIO8)
9090FPWM6: CN5.2 U4.15(FPWM6/GPIO10)
9090FPWM7: CN5.3 U4.16(FPWM7/GPIO11)
9090FPWM8: CN5.4 U4.17(FPWM8/GPIO12)
AMC0_SGMII2_RX_DN: AMC1.15(RX0-) C157.2
AMC0_SGMII2_RX_DN_R: C157.1 U23.AN26(SGMII0RXN2)
AMC0_SGMII2_RX_DP: AMC1.14(RX0+) C158.2
AMC0_SGMII2_RX_DP_R: C158.1 U23.AN27(SGMII0RXP2)
AMC0_SGMII2_TX_DN: AMC1.12(TX0-) U23.AL27(SGMII0TXN2)
AMC0_SGMII2_TX_DP: AMC1.11(TX0+) U23.AL26(SGMII0TXP2)
AMC1_SGMII3_RX_DN: AMC1.24(RX1-) C146.2
AMC1_SGMII3_RX_DN_R: C146.1 U23.AM25(SGMII0RXN3)
AMC1_SGMII3_RX_DP: AMC1.23(RX1+) C153.2
AMC1_SGMII3_RX_DP_R: C153.1 U23.AM26(SGMII0RXP3)
AMC1_SGMII3_TX_DN: AMC1.21(TX1-) U23.AK26(SGMII0TXN3)
AMC1_SGMII3_TX_DP: AMC1.20(TX1+) U23.AK25(SGMII0TXP3)
AMC2_SATA0_RX_DN: C226.2 U75.22(RXN_0)
AMC2_SATA0_RX_DP: C228.2 U75.21(RXP_0)
AMC2_SATA0_TX_DN: C233.2 U75.24(TXN_0)
AMC2_SATA0_TX_DP: C238.2 U75.25(TXP_0)
AMC4_PCIE0_RX0N: C176.2 U23.AN17(PCIE0RXN0)
AMC4_PCIE0_RX0P: C187.2 U23.AN18(PCIE0RXP0)
AMC4_PCIE0_TX0N: AMC1.45(TX4-) C662.2
AMC4_PCIE0_TX0N_R: C662.1 U23.AL18(PCIE0TXN0)
AMC4_PCIE0_TX0P: AMC1.44(TX4+) C649.2
AMC4_PCIE0_TX0P_R: C649.1 U23.AL17(PCIE0TXP0)
AMC5_PCIE0_RX1N: C162.2 U23.AM16(PCIE0RXN1)
AMC5_PCIE0_RX1P: C165.2 U23.AM17(PCIE0RXP1)
AMC5_PCIE0_TX1N: AMC1.51(TX5-) C634.2
AMC5_PCIE0_TX1N_R: C634.1 U23.AK17(PCIE0TXN1)
AMC5_PCIE0_TX1P: AMC1.50(TX5+) C610.2
AMC5_PCIE0_TX1P_R: C610.1 U23.AK16(PCIE0TXP1)
AMC_JTAG_TCK: AMC1.165(TCK) R578.1 U11.11(B3)
AMC_JTAG_TCK_1V8: U11.4(A3) U49.2(IA0)
AMC_JTAG_TDI: AMC1.169(TDI) R595.1 U11.13(B1)
AMC_JTAG_TDI_1V8: U7.2(IA0) U11.2(A1)
AMC_JTAG_TDO: AMC1.168(TDO) R591.1 U11.10(B4)
AMC_JTAG_TDO_1V8: U7.14(ID0) U11.5(A4)
AMC_JTAG_TMS: AMC1.166(TMS) R581.1 U11.12(B2)
AMC_JTAG_TMS_1V8: U7.5(IB0) U11.3(A2)
AMC_JTAG_TRST#: AMC1.167(T\R\S\T\) R585.1 U56.4(B)
AMC_JTAG_TRST#_1V8: U7.11(IC0) U56.3(A)
AMC_MDC_2V5: AMC1.129(RX15-) R621.1 R634.2
ATTENTIONZ: C102.1 R205.1 R211.2 U1.14(PJ0)
BD_ID0: CN7.104 U39.4(GPB3)
BD_ID1: CN7.106 U39.5(GPB4)
BD_ID2: CN7.108 U39.6(GPB5)
BD_PRESENT: CN7.102 U39.3(GPB2)
BOOTMODE14: U43.1(GPB0) U55.2(1A)
BOOTMODE15: U43.2(GPB1) U55.5(2A)
BOOTMODE_ON: R357.2 U43.3(GPB2) U55.1(1OE#) U55.7(2OE#)
BP3: C279.1 R278.2 R280.1 U34.27(BP3)
BP6: C849.1 U34.28(BP6)
BPCAP: C326.1 C327.2 U4.35(BPCAP)
BSC_JTAG_TCK: C12.2 R303.1 U3.2(1A)
BUFF_EMIFA00: CN7.6 U51.18(1Y1)
BUFF_EMIFA01: CN7.8 U51.16(1Y2)
BUFF_EMIFA02: CN7.10 U51.14(1Y3)
BUFF_EMIFA03: CN7.12 U51.12(1Y4)
BUFF_EMIFA04: CN7.14 U51.9(2Y1)
BUFF_EMIFA05: CN7.16 U51.7(2Y2)
BUFF_EMIFA06: CN7.18 U51.5(2Y3)
BUFF_EMIFA07: CN7.20 U51.3(2Y4)
BUFF_EMIFA08: CN7.22 U6.18(1Y1)
BUFF_EMIFA09: CN7.24 U6.16(1Y2)
BUFF_EMIFA10: CN7.26 U6.14(1Y3)
BUFF_EMIFA11: CN7.28 U6.12(1Y4)
BUFF_EMIFA12: CN7.30 U6.9(2Y1)
BUFF_EMIFA13: CN7.32 U6.7(2Y2)
BUFF_EMIFA14: CN7.34 U6.5(2Y3)
BUFF_EMIFA15: CN7.36 U6.3(2Y4)
BUFF_EMIFA16: CN7.38 U10.18(1Y1)
BUFF_EMIFA17: CN7.40 U10.16(1Y2)
BUFF_EMIFA18: CN7.42 U10.14(1Y3)
BUFF_EMIFA19: CN7.44 U10.12(1Y4)
BUFF_EMIFA20: CN7.46 U10.9(2Y1)
BUFF_EMIFA21: CN7.48 U10.7(2Y2)
BUFF_EMIFA22: CN7.50 U10.5(2Y3)
BUFF_EMIFA23: CN7.52 U10.3(2Y4)
BUFF_EMIFBE0Z: CN7.49 U54.18(1Y1)
BUFF_EMIFBE1Z: CN7.51 U54.16(1Y2)
BUFF_EMIFCE1Z: CN7.43 U54.14(1Y3)
BUFF_EMIFCE2Z: CN7.45 U54.12(1Y4)
BUFF_EMIFCE3Z: CN7.47 U54.9(2Y1)
BUFF_EMIFD0: CN7.9 U16.9(A8)
BUFF_EMIFD1: CN7.11 U16.8(A7)
BUFF_EMIFD2: CN7.13 U16.7(A6)
BUFF_EMIFD3: CN7.15 U16.6(A5)
BUFF_EMIFD4: CN7.17 U16.5(A4)
BUFF_EMIFD5: CN7.19 U16.4(A3)
BUFF_EMIFD6: CN7.21 U16.3(A2)
BUFF_EMIFD7: CN7.23 U16.2(A1)
BUFF_EMIFD8: CN7.25 U14.9(A8)
BUFF_EMIFD9: CN7.27 U14.8(A7)
BUFF_EMIFD10: CN7.29 U14.7(A6)
BUFF_EMIFD11: CN7.31 U14.6(A5)
BUFF_EMIFD12: CN7.33 U14.5(A4)
BUFF_EMIFD13: CN7.35 U14.4(A3)
BUFF_EMIFD14: CN7.37 U14.3(A2)
BUFF_EMIFD15: CN7.39 U14.2(A1)
BUFF_EMIFOEZ: CN7.53 U54.5(2Y3)
BUFF_EMIFRNW: CN7.65 U54.7(2Y2)
BUFF_EMIFWEZ: CN7.55 U54.3(2Y4)
CLK1_ELF: C33.1 R133.1 U18.41(ELF)
CLK1_REF_SEL: R157.1 U8.27(GPA6)
CLK1_SYNC: R136.1 U18.42(SYNCN)
CLK2_ELF: C44.1 R134.1 U17.41(ELF)
CLK2_REF_SEL: R154.1 U8.26(GPA5)
CLK2_SYNC: R113.2 U17.42(SYNCN)
CLK_RSTZ: U8.7(GPB6) U17.44(RESETN/PWR) U18.44(RESETN/PWR)
CORECLKN: C95.1 U18.33(Y6_N)
CORECLKP: C94.1 U18.32(Y6_P)
CP2105_MCU_U0RX: U2.21(TXD_SCI) U42.2(B)
CP2105_SOC_U0RX: U2.13(TXD_ECI) U52.2(B)
CPLD_A0: RN1.6(R3B) U9.2(IO12_8) U78.H7(A0)
CPLD_A1: RN1.8(R1B) U9.3(IO2_9) U78.H8(A1)
CPLD_A2: RN1.5(R4B) U9.5(IO12_10) U78.J8(A2)
CPLD_A3: RN1.7(R2B) U9.6(IO12_11) U78.J7(A3)
CPLD_BIO_0: R83.1 U9.42(IO12_4)
CPLD_BIO_1: RN2.7(R2B) U9.43(IO12_5)
CPLD_BIO_2: RN2.6(R3B) U9.44(IO12_6)
CPLD_BIO_3: R349.2 RN2.5(R4B) U9.1(IO12_7)
CPLD_BIO_4: R364.2 RN2.8(R1B) U9.41(IO12_3)
CPLD_CSN: R81.1 R362.1 U9.8(IO12_12)
CPLD_D0: RN5.4(R4A) U9.39(IO12_1) U78.A8(DQ0)
CPLD_D1: RN5.3(R3A) U9.40(IO12_2) U78.B9(DQ1)
CPLD_RDN: R82.1 R363.2 U9.12(IO12_13)
CPLD_RESETN: R347.2 U9.13(IO12_14) U15.B10(EMA_A[21]/MMCSD0_DAT[0]/GP4[5])
CPLD_RXD1: R364.1 U15.E18(SPI1_SCS[3]/UART1_RXD/SATA_LED/)
CPLD_TCK: R170.1 R351.1 TP13.1 U9.11(TCK)
CPLD_TDI: TP11.1 U9.9(TDI) U15.U1(VP_DOUT[6]/LCD_D[6]/UPP_XD[14]/)
CPLD_TDO: TP30.1 U9.24(TDO) U15.U2(VP_DOUT[7]/LCD_D[7]/UPP_XD[15]/)
CPLD_TMS: R350.1 TP12.1 U9.10(TMS) U15.V3(VP_DOUT[5]/LCD_D[5]/UPP_XD[13]/)
CPLD_TXD1: R349.1 U15.F19(SPI1_SCS[2]/UART1_TXD/SATA_CP_P)
CPLD_WEN: R72.2 R79.1 U9.14(IO12_15) U78.F9(W\E\)
