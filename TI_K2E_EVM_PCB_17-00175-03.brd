# Allegro board TI_K2E_EVM_PCB_17-00175-03.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XFICLKP_R: length 4.1
  TOP w0.152: U18.14 64.17,91.23 64.23,91.16 64.23,90.52 64,90.28 62.62,90.28 62.48,90.42 61.98,90.42 61.74,90.66 R672.1
N854872: length 20.4
  TOP w0.127: U23.AH5 v6(52.78,70.96)
  BOTTOM w0.127: v6(52.78,70.96) 53.15,71.34 53.15,71.92 52.88,72.18 51.82,72.18 51.55,72.45 51.55,72.72 51.33,72.93 51.33,74.68
  BOTTOM w0.152: 51.33,74.68 51.33,76.66 46.81,81.18 46.81,81.81 44.37,84.26 R631.1 R632.1
N854876: length 19.6
  TOP w0.127: U23.AH6 v6(52.78,70.16)
  BOTTOM w0.152: R629.1 R630.1 50.56,75.31 50.79,75.08 50.79,70.8 51.03,70.55 52.39,70.55 v6(52.78,70.16)
N859795: length 32.3
  TOP w0.152: R645.1 R646.1 50.72,90.35 v1(50.97,90.61) ; U23.AE7 v6(55.18,69.36)
  L10_SIG4 w0.107: v1(50.97,90.61) 50.55,90.18 50.55,89.46 51.23,88.77 51.23,88.01 51.03,87.81 49.48,87.81 47.19,85.52 47.19,84.36 47.48,84.07 48.32,84.07 55.54,76.85 55.54,71.61 55.33,71.39 55.09,71.39 54.81,71.11 54.81,69.73 v6(55.18,69.36)
N859809: length 24.9
  TOP w0.152: R643.1 R644.1 43.43,87.94 v2(43.14,87.65) ; U23.AF6 v6(54.38,70.16)
  L10_SIG4 w0.107: v2(43.14,87.65) 43.74,87.06 43.74,84.1 53.94,73.89 53.94,70.87 54.38,70.44 v6(54.38,70.16)
N12934666: length 4
  TOP w0.152: CN3.1 v1(102.11,136.14)
  BOTTOM w0.152: v1(102.11,136.14) R311.2
N13012268: length 2.6
  TOP w0.152: U1.96 135.19,146.22 v1(135.23,146.25)
  BOTTOM w0.152: R290.2 135.1,145.48 135.19,145.58 135.19,146.22 v1(135.23,146.25)
N13662493: length 3.8
  TOP w0.152: CN3.2 102.11,144.15 102.36,144.4 v1(102.36,144.91)
  BOTTOM w0.152: R304.2 v1(102.36,144.91)
N13662497: length 3.8
  TOP w0.152: CN3.4 103.38,144.39 v1(103.89,144.89)
  BOTTOM w0.152: v1(103.89,144.89) R303.2
N13662501: length 3.9
  TOP w0.152: v1(105.41,144.89) 104.65,144.13 CN3.6
  BOTTOM w0.152: v1(105.41,144.89) R302.2
N13662505: length 4.4
  TOP w0.152: v1(106.93,144.89) 106.41,144.89 105.92,144.4 CN3.8
  BOTTOM w0.152: v1(106.93,144.89) R301.2
N13662509: length 4.5
  TOP w0.152: v1(108.46,144.89) 107.81,144.89 107.19,144.27 CN3.10
  BOTTOM w0.152: v1(108.46,144.89) R300.2
N14462583: length 1.1
  TOP w0.152: U23.AJ27 v6(51.98,52.56)
  BOTTOM w0.127: R479.1 v6(51.98,52.56)
N14463052: length 1.1
  TOP w0.152: U23.AG14 v6(53.58,63.76)
  BOTTOM w0.127: R460.1 v6(53.58,63.76)
N14463586: length 1.1
  TOP w0.152: U23.AJ5 v6(51.98,70.96)
  BOTTOM w0.254: R434.2 v6(51.98,70.96)
N14466276: length 1.1
  TOP w0.152: U23.AH7 v6(52.78,69.36)
  BOTTOM w0.127: R441.2 v6(52.78,69.36)
N14466300: length 1.1
  TOP w0.152: U23.AG10 v6(53.58,66.96)
  BOTTOM w0.127: R446.2 v6(53.58,66.96)
N14466840: length 1.1
  TOP w0.254: U23.Y6 v6(59.18,70.16)
  BOTTOM w0.254: R438.2 v6(59.18,70.16)
N14469420: length 1.1
  TOP w0.152: U23.G12 v6(70.38,65.36)
  BOTTOM w0.254: R454.1 v6(70.38,65.36)
N14469428: length 1.2
  TOP w0.152: U23.G18 v6(70.38,59.76)
  BOTTOM w0.254: R467.1 v6(70.38,59.76)
N14469440: length 1.2
  TOP w0.152: U23.E15 v6(71.98,62.96)
  BOTTOM w0.254: R465.1 v6(71.98,62.96)
N14711749: length 3.2
  TOP w0.254: 113.4,134 113.57,133.83 U4.34
  TOP w0.381: 113.4,134 112.29,135.1 C9.1
N14714084: length 3
  TOP w0.152: U4.6 115.07,124.46 114.4,123.8 R60.1
N14714150: length 3.5
  TOP w0.152: U4.4 114.07,124.61 113.67,124.21 113.16,124.21 112.9,123.95 R61.1
N14714160: length 3.8
  TOP w0.152: U4.5 v1(114.57,124.85)
  BOTTOM w0.152: R337.1 113.63,123.11 113.82,123.29 113.82,124.1 v1(114.57,124.85)
N14715464: length 3.9
  TOP w0.152: R36.2 120.96,127.93 120.57,128.32 120.57,128.75 119.79,129.54 U4.19
N14715500: length 3.9
  TOP w0.152: R30.2 v1(120.96,129.39) 120.43,129.39 119.78,130.04 U4.20
  BOTTOM w0.152: R30.2 v1(120.96,129.39)
N14716011: length 6.4
  TOP w0.152: U4.31 115.07,134.16 114.74,134.49 113.67,134.49 113.54,134.62 R15.2 113.98,135.06 114.16,135.24 114.16,136.54 TP4.1
N14719575: length 3
  TOP w0.152: U4.43 v3(110.88,129.04)
  BOTTOM w0.152: R325.2 110.11,127.76 110.88,128.53 v3(110.88,129.04)
N14725158: length 3.2
  TOP w0.152: U4.7 v1(115.57,124.85)
  BOTTOM w0.152: R336.1 114.43,123.71 v1(115.57,124.85)
N14733790: length 2.3
  TOP w0.152: R26.1 120.14,130.18 119.78,130.54 U4.21
N14872798: length 2.4
  TOP w0.152: R133.2 64.3,102.93 64.01,103.23 C34.2
N14873463: length 4.1
  TOP w0.254: R134.2 85.31,102.67 84.59,102.67 84.04,103.22 84.04,104.92 84.22,105.1 C36.2
N14877032: length 7.2
  TOP w0.102: R602.1 R178.2 78.92,88.7 79.08,88.86 79.08,92.2 79.37,92.5 80.02,92.5 80.15,92.62 U17.11
N15165762: length 2.7
  TOP w0.152: U4.26 117.57,133.72 118.49,134.65 R12.1
N15567426: length 2
  TOP w0.152: v1(140.77,130.53) 140.77,130.2 140.69,130.13 U1.41
  BOTTOM w0.152: R663.2 v1(140.77,130.53)
N15571799: length 3.6
  TOP w0.152: CN1.1 R9.1
N15783945: length 4.6
  TOP w0.152: U4.11 117.57,125.08 118.36,124.28 119.7,124.28 120.4,123.58 R56.1
N16053779: length 2.3
  TOP w0.152: U1.19 132.57,134.16 132.66,134.06 v1(132.67,134.06)
  BOTTOM w0.152: R319.2 132.49,133.99 132.57,134.06 132.66,134.06 v1(132.67,134.06)
N16114816: length 3.9
  TOP w0.152: R50.1 120.96,124.5 119.63,125.83 119.63,126.73 119.33,127.04 U4.14
N16281952: length 2.7
  TOP w0.152: v1(113.54,145.69) 114.24,144.99 RST_BMC1.2
  BOTTOM w0.152: v1(113.54,145.69) R297.1
N16316172: length 2.3
  TOP w0.152: U1.17 132.43,135.16 v1(132.59,135)
  BOTTOM w0.152: v1(132.59,135) 132.44,135.15 132.42,135.15 132.19,135.38 R318.2
N16319325: length 3.2
  TOP w0.152: U1.61 148.75,136.16 149.41,135.5 R16.1
N16321972: length 2
  BOTTOM w0.152: U41.10 137.8,137.04 137.61,136.85 R317.1
N16474415: length 1.3
  TOP w0.152: R89.1 D5.1
N16474431: length 6.4
  TOP w0.152: Q6.3 175.48,115.09 176.4,114.17 176.4,112.9 177.16,112.15 D5.2
N16572263: length 3
  TOP w0.152: v1(132.59,135.61) 132.54,135.61 132.49,135.66 U1.16
  BOTTOM w0.152: R312.2 132.21,136.78 132.59,136.4 v1(132.59,135.61)
N16795853: length 3.5
  TOP w0.152: R11.1 119.33,135.06 118.07,133.79 U4.25
N16795860: length 4.5
  TOP w0.152: U4.24 118.82,133.8 119.63,134.62 R17.1
N16800870: length 3.1
  TOP w0.152: Q6.1 173.8,113.97 173.55,114.22 R75.2
N16809812: length 2.5
  TOP w0.152: CN7.81 R54.1
N16865403: length 3.2
  BOTTOM w0.152: R365.2 173.3,113.1 173.8,113.6 Q14.1
N16865412: length 1.6
  TOP w0.152: D6.1 v1(179.2,108.2)
  BOTTOM w0.152: R377.1 v1(179.2,108.2)
N16865430: length 5.8
  TOP w0.152: D6.2 178.49,110.56 178.23,110.82 v1(178.23,111.38)
  BOTTOM w0.152: Q14.3 177.58,112.49 178.23,111.83 v1(178.23,111.38)
N16865801: length 3.2
  BOTTOM w0.152: Q11.1 173.93,128.64 173.68,128.39 R328.2
N16865808: length 1.5
  TOP w0.152: D3.2 R32.1
N16865818: length 4.2
  TOP w0.152: D3.1 177.16,129.92 176.69,129.45 Q3.3
N16865822: length 1.5
  TOP w0.152: D4.2 178.35,125.04 178.08,124.77 R47.1
N16865834: length 4.3
  TOP w0.152: v1(177.67,126.36) 177.95,126.64 D4.1
  BOTTOM w0.152: v1(177.67,126.36) 177.2,126.84 Q11.3
N16865898: length 3.3
  TOP w0.152: R27.2 173.68,127.89 173.93,127.64 Q3.1
N16869469: length 1.4
  TOP w0.152: R108.2 C42.1
N16870184: length 1.4
  BOTTOM w0.152: C45.1 R112.2
N16947500: length 1.3
  TOP w0.152: R46.2 C18.1
N16951277: length 1.1
  TOP w0.152: U23.AJ22 v6(51.98,56.56)
  BOTTOM w0.127: R472.1 v6(51.98,56.56)
N16953830: length 1.1
  TOP w0.152: U23.AJ10 v6(51.98,66.96)
  BOTTOM w0.127: R449.1 v6(51.98,66.96)
N16953906: length 3.3
  BOTTOM w0.102: C782.1 27.25,32.58 27.41,32.74 28.93,32.74 29.07,32.88 29.44,32.88 29.52,32.81 U75.33
N16953908: length 3.7
  BOTTOM w0.102: C769.1 27.25,36.06 27.38,35.93 27.82,35.93 28.03,35.71 28.19,35.71 28.77,35.13 29.44,35.13 29.52,35.21 U75.39
N16953910: length 3.7
  BOTTOM w0.102: U75.38 29.52,34.81 29.44,34.88 28.67,34.88 28.09,35.46 27.93,35.46 27.71,35.67 27.38,35.67 27.25,35.54 C770.1
N16953912: length 3.5
  BOTTOM w0.102: C771.1 27.25,33.31 27.56,32.99 28.83,32.99 28.97,33.13 29.44,33.13 29.52,33.21 U75.34
N16954088: length 6.3
  TOP w0.152: TP58.1 28.32,27.76 v1(28.71,28.14)
  L3_SIG1 w0.107: v1(31.37,31.24) 31.37,30.45 29.06,28.14 v1(28.71,28.14)
  BOTTOM w0.203: U75.27 v1(31.37,31.24)
N16997326: length 3.7
  BOTTOM w0.102: C816.2 129.01,21.27 128.91,21.17 128.91,20.48 129.14,20.24 129.75,20.24 130.1,19.9 130.1,19.63 130.22,19.51 U77.2
N16997342: length 3.7
  BOTTOM w0.102: U77.1 129.72,19.48 129.84,19.6 129.84,19.8 129.65,19.99 129.03,19.99 128.65,20.37 128.65,21.17 128.55,21.27 C817.2
N17001107: length 3.9
  BOTTOM w0.152: R576.1 137.72,8.64 137.07,9.28 137.07,9.28 137.03,9.33 135.72,10.64 U77.30
N17001211: length 4.8
  BOTTOM w0.152: TP88.1 138.39,9.88 136.93,9.88 136.22,10.59 U77.29
N17001218: length 3.2
  BOTTOM w0.152: TP89.1 136.78,8.64 135.22,10.2 U77.31
N17001225: length 4.5
  BOTTOM w0.152: U77.32 134.72,10.26 136.04,8.95 136.04,8.17 TP90.1
N17007218: length 4.7
  TOP w0.152: R190.1 12.7,86.17 12.86,86.34 12.86,88.46 J4.C2
N17199371: length 20
  TOP w0.254: R264.2 168.45,7.75 167.07,9.13 167.07,16.09 167.85,16.88 172.29,16.88 172.68,16.48 J9.12A
N17199383: length 5.8
  TOP w0.254: J9.14A 172.04,27.68 172.04,31.76 172.22,31.94 R248.2
N17200454: length 2.5
  BOTTOM w0.152: R568.1 126.82,16.42 127.2,16.81 128.38,16.81 128.39,16.8 U77.53
N17200461: length 4.2
  BOTTOM w0.152: U77.56 128.2,18.3 127.53,18.97 127.53,20.51 127.21,20.83 R559.1
N17200465: length 3.2
  BOTTOM w0.152: R562.1 126.82,18.73 127.74,17.8 U77.55
N17200469: length 2.4
  BOTTOM w0.152: U77.54 127.66,17.3 127.18,17.78 R564.1
N17200473: length 3
  BOTTOM w0.152: U77.51 129.01,15.79 127.32,15.79 126.82,15.29 R571.1
N17200477: length 3.9
  BOTTOM w0.152: U77.50 128.39,15.3 128.38,15.31 127.96,15.31 127.73,15.08 127.73,13.73 127.21,13.21 R572.1
N17204930: length 1.6
  BOTTOM w0.508: C831.1 154.63,16.45 J9.9A
N17205278: length 3.8
  BOTTOM w0.152: TP87.1 134.87,20.7 133.72,19.55 U77.9
N17206950: length 9.5
  BOTTOM w0.152: U77.33 134.22,9.8 134.68,9.35 C844.2 134.68,5.19 Y8.3
N17206970: length 6.2
  BOTTOM w0.152: U77.34 133.72,9.43 133.42,9.13 C845.2 R579.1 133.42,6.62 132.93,6.13 Y8.1
N17261802: length 2.8
  TOP w0.152: R33.1 109.67,128.26 109.94,128.54 U4.44
N17416492: length 3.1
  BOTTOM w0.152: U75.13 39.12,31.61 39.3,31.43 R552.1
N17426925: length 3.9
  TOP w0.152: R250.1 27.25,31.63 27.38,31.5 v1(28.19,31.5)
  BOTTOM w0.152: v1(28.19,31.5) 28.71,32.01 U75.31
N17447628: length 9.5
  BOTTOM w0.152: Y6.3 23.43,31.79 24.16,31.06 R554.1 26,31.06 26.9,30.16 C791.2 28.4,30.16 28.76,30.51 28.76,31.17 29.19,31.61 U75.30
N17447634: length 12.8
  BOTTOM w0.152: U75.29 29.45,31.21 29.16,30.91 29.16,30.22 27.97,29.03 C795.2 R555.1 R554.2 21.22,30.16 21.02,29.96 Y6.1
N17467804: length 2.9
  BOTTOM w0.152: C848.1 129.54,8.95 130.22,9.63 U77.41
N17467824: length 7.7
  BOTTOM w0.152: C848.2 129.54,6.86 129.92,6.48 131.32,6.48 131.7,6.86 131.7,9.27 132.23,9.8 132.23,10.53 132.21,10.55 132.21,11.09 U77.37
N17469110: length 3.1
  BOTTOM w0.152: R548.1 39.3,32.51 38.21,33.61 U75.8
N17469117: length 2.5
  BOTTOM w0.127: U75.6 38.09,34.41 38.13,34.45 38.82,34.45 38.91,34.54
  BOTTOM w0.152: 38.91,34.54 R543.1
N17469130: length 2.8
  BOTTOM w0.152: U75.3 37.79,35.61 37.98,35.8 39.18,35.8 39.3,35.92 R531.1
N17470441: length 2.7
  TOP w0.152: NOR1.1 138.3,50.65 137.7,51.25 R428.2
N17470469: length 3.8
  TOP w0.127: NOR1.8 138.2,41.76 137.1,42.86 R447.1
N17470666: length 24.4
  TOP w0.152: U23.N29 v6(65.58,50.96)
  BOTTOM w0.152: v6(65.58,50.96) 65.17,50.56 65.17,47.66 68.05,44.78 73.43,44.78 78.97,39.24 80.52,39.24 81.05,38.7 R525.1
N17470672: length 33.1
  TOP w0.152: U23.M30 v6(66.38,50.16)
  BOTTOM w0.152: v6(66.38,50.16) 65.97,49.76 65.97,47.36 68.24,45.09 76.38,45.09 77.09,45.8 81.74,45.8 83.64,43.89 83.64,40.83 81.79,38.98 81.79,35.74 81.29,35.25 R540.1
N17494072: length 31.3
  TOP w0.152: U23.L31 v6(67.18,49.36)
  BOTTOM w0.152: v6(67.18,49.36) 67.18,47.28 68.76,45.69 76.13,45.69 76.84,46.41 81.99,46.41 84.25,44.14 84.25,40.58 83.01,39.34 83.01,35.81 R539.1
N17494427: length 24.2
  TOP w0.127: U23.T33 62.78,47.32
  TOP w0.152: R235.2 72.94,41.4 62.66,41.4 61.98,42.09 61.98,46.52 62.78,47.32
N17494476: length 26.2
  TOP w0.127: U23.T32 63.18,48.56 63.18,47.32
  TOP w0.152: 63.18,47.32 63.18,47.29 62.28,46.39 62.28,42.29 62.87,41.71 73.56,41.71 78.52,36.75 R234.2
N17495593: length 30.6
  TOP w0.152: U23.K31 v6(67.98,49.36)
  BOTTOM w0.152: v6(67.98,49.36) 67.98,47.69 69.36,46.3 75.87,46.3 76.58,47.02 82.24,47.02 84.86,44.4 84.86,40.33 84.48,39.95 84.48,36.3 83.85,35.66 R538.2
N17495612: length 29.1
  TOP w0.152: U23.K30 v6(67.98,50.16)
  BOTTOM w0.152: R523.2 83.85,39.74 84.56,40.45 84.56,44.27 82.12,46.71 76.71,46.71 76,46 68.88,46 67.57,47.31 67.57,49.76 v6(67.98,50.16)
N17501624: length 1.7
  TOP w0.152: U21.5 14.35,81.79 13.97,82.17 R193.1
N17511358: length 2
  BOTTOM w0.152: U50.6 164.04,122.92 164.53,123.41 C342.1
N17511366: length 1.9
  BOTTOM w0.152: U50.2 161.44,123.25 161.6,123.41 C343.1
N17511368: length 2.5
  BOTTOM w0.152: U50.16 160.79,114.56 160.6,114.37 R361.2
N17511372: length 1.9
  BOTTOM w0.152: U50.4 162.74,123.02 162.5,123.27 C343.2
N17511396: length 3.5
  BOTTOM w0.152: U50.3 162.09,121.33 161.93,121.16 160.53,121.16 160.44,121.25 C346.1
N17511408: length 2.6
  BOTTOM w0.152: U50.7 164.69,123.06 164.87,123.23 165.49,123.23 165.67,123.41 C341.2
N17511414: length 1.7
  BOTTOM w0.152: R359.2 163.58,114.88 163.39,115.06 U50.12
N17511418: length 1.9
  BOTTOM w0.152: U50.5 163.39,123.02 163.63,123.27 C342.2
N17580617: length 25
  TOP w0.152: U23.T30 v6(63.18,50.16)
  BOTTOM w0.152: R527.2 77.67,37.91 73.86,41.73 64.89,41.73 64.68,41.93 64.68,45.14 62.78,47.04 62.78,47.61 62.78,47.94 62.78,47.94 62.78,49.77 v6(63.18,50.16)
N17583891: length 4.3
  TOP w0.152: Q4.3 175.48,124.49 176.73,123.24 DBG_D1.3
N17583895: length 5.4
  TOP w0.152: Q5.3 175.23,119.67 177.45,117.44 DBG_D2.1
N17583899: length 1.5
  TOP w0.152: DBG_D1.1 177.67,120.14 177.67,120.14 R69.1
N17583903: length 5.3
  TOP w0.152: DBG_D3.1 177.94,115.07 v1(177.93,115.06)
  BOTTOM w0.152: v1(177.93,115.06) 175.93,117.06 Q13.3
N17583929: length 1.3
  TOP w0.152: R73.1 DBG_D3.2
N17583981: length 3.2
  TOP w0.152: Q5.1 173.8,118.67 173.55,118.92 R70.2
N17584002: length 3.1
  BOTTOM w0.152: R353.2 173.55,118.61 173.8,118.87 Q13.1
N17584047: length 1.2
  TOP w0.152: R71.1 DBG_D2.2
N17584060: length 3.2
  TOP w0.152: R48.2 173.55,123.11 173.8,122.86 Q4.1
N17584073: length 3.2
  TOP w0.152: DBG_D1.2 v1(176.78,121.69)
  BOTTOM w0.152: v1(176.78,121.69) 176.59,121.89 Q12.3
N17584084: length 3.3
  BOTTOM w0.152: R340.2 173.55,122.69 173.8,122.94 Q12.1
N17624377: length 1.1
  TOP w0.102: U23.AJ24 v6(51.98,54.96)
  BOTTOM w0.102: C673.2 v6(51.98,54.96)
N17624382: length 1.1
  TOP w0.102: U23.AJ25 v6(51.98,54.16)
  BOTTOM w0.102: C681.2 v6(51.98,54.16)
N17624472: length 6.1
  TOP w0.102: C95.2 55,78.85 55.18,78.66 55.18,76.55 54.25,75.62 54.25,74.03 U23.AG1
N17624476: length 6.1
  TOP w0.102: C94.2 55.61,78.85 55.44,78.68 55.44,76.45 54.5,75.51 54.5,74.03 U23.AF1
N17626857: length 7.2
  TOP w0.102: R601.1 R177.2 79.45,88.7 79.33,88.82 79.33,89.31 79.45,89.43 79.45,89.66 79.33,89.78 79.33,90.01 79.45,90.13 79.45,90.36 79.33,90.48 79.33,90.7 79.45,90.82 79.45,91.05 79.33,91.17 79.33,91.4 79.45,91.52 79.45,91.75 79.33,91.87 79.33,92.1 79.48,92.24 80.02,92.24 80.15,92.12 U17.12
N17628895: length 9.1
  TOP w0.152: C59.1 77.22,91.54 R171.2 77.25,91.76 75.74,93.27 75.74,94.54 75.99,94.79 R161.2 ; R161.2 R155.1 ; R161.2 R160.2
N17655103: length 1.4
  TOP w0.254: U23.V5 v6(60.78,70.96)
  BOTTOM w0.254: v6(60.78,70.96) 61.28,70.94 61.47,70.94 R436.2
N17664197: length 21
  TOP w0.114: J7.8 166.2,58.41 arc(166.66,58.32) 167.05,58.06 167.83,57.28 arc(167.89,57.24) 167.96,57.23 arc(168.2,57.13) 168.3,56.88 168.3,56.01 arc(168.24,55.71) 168.07,55.45 167.14,54.52 arc(165.54,53.86) 163.95,54.52 arc(163.52,55.16) 163.37,55.91 163.37,61.23 arc(163.31,61.52) 163.15,61.77 163.12,61.8 arc(163.05,61.84) 162.98,61.86 162.54,61.86 arc(162.36,61.82) U30.11 arc(161.96,61.82) 161.69,61.86 arc(161.42,61.82) U30.4 arc(161.01,61.83) 160.82,61.86 160.13,61.86 arc(159.75,61.79) L9.3
N17664207: length 20.2
  TOP w0.114: J7.9 166.21,55.91 arc(166.67,56) 167.05,56.26 167.51,56.72 167.68,56.88 arc(167.81,56.97) 167.96,57 arc(168.04,56.96) 168.07,56.88 168.07,56.01 arc(168.03,55.8) 167.91,55.62 166.98,54.69 arc(165.54,54.09) 164.11,54.69 arc(163.73,55.25) 163.6,55.91 163.6,61.23 arc(163.52,61.61) 163.31,61.93 163.28,61.96 arc(163.14,62.05) 162.98,62.09 162.54,62.09 arc(162.36,62.12) U30.12 arc(161.96,62.12) 161.69,62.09 arc(161.42,62.12) U30.3 arc(161.01,62.12) 160.84,62.09 160.13,62.09 arc(159.75,62.16) L9.4
N17665181: length 1.7
  TOP w0.114: C129.1 165.75,49.8 arc(165.85,49.58) 166.07,49.49 166.23,49.49 arc(166.6,49.56) L4.1
N17667106: length 4.8
  TOP w0.152: R222.1 160.59,36.45 R220.2
  TOP w0.381: U26.4 R222.1 ; R220.2 U27.4
N17684391: length 9.5
  TOP w0.102: AMC1.33 4.84,29.25 5.09,29 9.56,29 10.08,29.53 12.14,29.53 12.25,29.63 C226.1
N17684393: length 9.5
  TOP w0.102: AMC1.32 4.84,28.5 5.09,28.75 9.66,28.75 10.19,29.27 12.14,29.27 12.25,29.16 C228.1
N17684395: length 9.3
  TOP w0.102: C233.1 12.25,26.84 12.16,26.75 5.09,26.75 4.84,27 AMC1.30
N17684397: length 9.3
  TOP w0.102: C238.1 12.25,26.39 12.14,26.5 5.09,26.5 4.84,26.25 AMC1.29
N17685557: length 9
  BOTTOM w0.152: R489.1 10.79,49.53 10.01,48.75 AMC1.112
N17687628: length 36.2
  TOP w0.152: U23.AM31 v6(49.58,49.36)
  L3_SIG1 w0.102: v1(22.66,57.31) 23.65,56.32 23.65,51.16 26.07,48.73 39.93,48.73 40.68,49.48 47.62,49.48 47.9,49.76 49.12,49.76 49.52,49.36 v6(49.58,49.36)
  BOTTOM w0.152: U68.2 v1(22.66,57.31)
N17687639: length 41.1
  TOP w0.152: U23.AL33 v6(50.38,47.76)
  L3_SIG1 w0.102: v6(50.38,47.76) 49.63,47.02 42.09,47.02 41.49,46.42 39.86,46.42 39.19,47.1 23.47,47.1 21.29,49.29 21.29,55.58 v1(21.84,56.13)
  BOTTOM w0.152: v1(21.84,56.13) 22.37,56.66 U68.3
N17687855: length 9.3
  BOTTOM w0.152: AMC1.111 9.93,49.5 11.36,50.93 R485.1
N17705388: length 3.2
  TOP w0.254: C149.1 136.02,54.97 135.37,55.62 U25.9
N17705392: length 4.9
  TOP w0.254: 130.48,56.12 130.48,56.36 130.73,56.62 U25.4 ; 130.48,56.12 C139.1 129.87,55.93 130.18,55.62 U25.6 ; 130.48,56.12 U25.5
N17705416: length 3.5
  TOP w0.254: R218.1 131.4,53.6 131.8,54 132.36,54 132.5,54.14 U25.7
  TOP w0.381: R219.1 R218.1
N17705473: length 1.6
  TOP w0.254: U25.8 134,54.1 133.66,53.77 R217.2
N17705475: length 1.3
  TOP w0.152: R217.1 C152.1
N17705504: length 1.5
  TOP w0.381: C148.1 R221.1
N17705537: length 2.4
  TOP w0.254: R216.2 132.26,60.02 132.5,59.78 U25.1
N17705615: length 3
  TOP w0.254: TP49.1 R215.1 U25.14
N17705627: length 2.7
  TOP w0.254: U25.11 136.08,56.62 ; U25.12 C134.2
N17705639: length 1.7
  TOP w0.254: U25.13 135.79,57.62 136.19,58.02 C134.1
N17709052: length 4.2
  TOP w0.254: C105.1 150.39,74.35 150.6,74.15 150.6,72.24 151.32,71.51 U22.9
N17709056: length 4.9
  TOP w0.254: U22.5 156.21,71.01 ; 156.21,71.01 156.21,70.76 155.96,70.51 U22.4 ; 156.21,71.01 C112.1 156.82,71.2 156.51,71.51 U22.6
N17709080: length 4.5
  TOP w0.254: R209.1 155.8,72.84 155.22,72.26 U22.7
  TOP w0.381: R209.1 R204.2
N17709137: length 2
  TOP w0.254: U22.8 152.69,73.02 153.03,73.36 R208.1
N17709139: length 2.2
  TOP w0.381: R208.2 151.38,74.97 151.31,75.04 C103.1
N17709168: length 1.4
  TOP w0.381: R207.1 C106.1
N17709201: length 1.5
  TOP w0.254: U22.1 R212.2
N17709279: length 2.9
  TOP w0.254: TP46.1 151.38,67.56 R213.1 U22.14
N17709291: length 3.1
  TOP w0.254: U22.11 150.22,70.51 ; U22.12 C117.2
N17709303: length 1.7
  TOP w0.152: U22.13 151.19,69.51 151.16,69.5 151.01,69.34 150.35,69.34 C117.1
N17728755: length 0.8
  BOTTOM w0.254: U74.1 117.92,34.2 117.68,33.96
N17728967: length 4.9
  BOTTOM w0.152: U74.9 122.3,34.7 123.02,35.42 R532.1 123.02,35.74 123.66,36.39 124.47,36.39 TP78.1
N17793041: length 2.5
  TOP w0.381: R254.2 49.4,23.62 49.76,23.98 D10.1
N17836608: length 1.3
  BOTTOM w0.152: U65.9 24.05,69.4 24.02,69.43 R439.1
N17928857: length 1.5
  TOP w0.152: R98.2 TP17.1
N17928862: length 10.3
  TOP w0.127: v1(141.02,108.88) U15.C5
  TOP w0.152: R98.1 134.39,110.87 v1(135.1,111.58)
  BOTTOM w0.152: v1(135.1,111.58) 135.33,111.35 135.33,109.37 136.23,108.48 140.61,108.48 v1(141.02,108.88)
N17928972: length 1.5
  TOP w0.152: TP23.1 R107.2
N17928982: length 1.5
  TOP w0.152: R102.2 TP19.1
N17929018: length 1.5
  TOP w0.152: TP21.1 R106.2
N17929020: length 7.3
  TOP w0.152: R107.1 134.73,106.17 134.73,106.14 134.96,105.91 136.08,105.91 137.44,107.27 140.24,107.27 U15.E4
N17929025: length 6.5
  TOP w0.127: 134.18,109.28 R102.1
  TOP w0.152: U15.C3 139.44,108.87 137.27,108.87 137.06,108.66 134.36,108.66 134.18,108.84 134.18,109.28
N17929027: length 6.8
  TOP w0.152: U15.D4 140.24,108.07 137.36,108.07 136.87,107.57 135.72,107.57 135.59,107.7 R106.1
N17929181: length 1.6
  TOP w0.152: v1(156.97,111.25) 157.86,111.25 TP16.1
  BOTTOM w0.152: R368.2 v1(156.97,111.25)
N17929183: length 3
  TOP w0.152: TP22.1 156.82,106.96 v1(156.79,106.93)
  BOTTOM w0.152: R381.2 156.27,105.85 156.79,106.38 v1(156.79,106.93)
N17929185: length 5.2
  TOP w0.127: U15.F17 v1(151.42,106.48)
  BOTTOM w0.127: 153.47,106.88 151.81,106.88 v1(151.42,106.48)
  BOTTOM w0.152: 153.47,106.88 153.86,106.88 154.14,107.16 155,107.16 155.41,106.75 R381.1
N17929187: length 9.4
  TOP w0.127: U15.F16 v1(150.62,106.48)
  L10_SIG4 w0.107: v1(150.62,106.48) 151,106.1 153.17,106.1 153.4,106.33 153.4,108.9 v1(155.02,110.52)
  BOTTOM w0.152: v1(155.02,110.52) 155.51,111.01 R368.1
N17929697: length 6.9
  TOP w0.127: U15.P16 v1(150.62,99.28)
  L5_SIG2 w0.107: v1(150.62,99.28) 150.62,95.48 v3(151.64,94.46)
  BOTTOM w0.152: R398.1 v3(151.64,94.46)
N17929849: length 5.4
  TOP w0.127: U15.N17 v1(151.42,100.08)
  BOTTOM w0.127: v1(151.42,100.08) 151.42,100.34 151.81,100.72 151.81,101.02 152.06,101.27 153.46,101.27 153.47,101.27
  BOTTOM w0.152: 153.47,101.27 153.57,101.27 154.13,100.71 C389.1
N17929864: length 0.6
  TOP w0.254: U15.N14 v1(149.02,100.08)
  vias: v3(147.9,94.51) v3(147.9,93.57)
N17936032: length 6.5
  TOP w0.152: U15.T18 152.2,97.7 152.79,97.7 153.11,97.38 153.11,93.47 153.37,93.22 TP34.1
N17936096: length 6
  TOP w0.152: U15.V2 139.02,96.27 138.6,95.85 138.6,95.23 R170.2
N17937670: length 12.1
  TOP w0.127: U15.K16 v1(150.62,102.48)
  TOP w0.152: R114.1 v1(161.29,103)
  L10_SIG4 w0.107: v1(161.29,103) 151.13,103 v1(150.62,102.48)
N17937746: length 15.4
  TOP w0.127: U15.K14 v1(149.02,102.48)
  L5_SIG2 w0.107: v3(152.55,94.06) 151.31,94.06 148.64,96.73 148.64,102.1 v1(149.02,102.48)
  BOTTOM w0.152: R395.2 R396.2 R397.2 152.56,94.05 v3(152.55,94.06)
N17937762: length 12.3
  TOP w0.127: U15.J16 v1(150.62,104.08)
  L5_SIG2 w0.107: v1(157.73,109.02) 157.35,109.4 155.35,109.4 153.89,107.94 153.89,106.49 152.7,105.3 152.1,105.3 151.8,105 151.8,104.73 151.57,104.5 151.04,104.5 v1(150.62,104.08)
  BOTTOM w0.152: v1(157.73,109.02) 158.09,109.02 158.44,109.36 R374.1
N17938891: length 2.5
  TOP w0.152: D9.1 v1(173.02,107.82)
  BOTTOM w0.152: v1(173.02,107.82) R373.1
N17938893: length 2
  TOP w0.152: D8.1 v1(175.14,108.04)
  BOTTOM w0.152: R372.1 v1(175.14,108.04)
N17939061: length 2.2
  TOP w0.152: Q7.3 D9.2
N17939063: length 10.4
  TOP w0.152: D8.2 175.14,111.25 174.81,111.58 167.09,111.58 166.76,111.25 166.76,111.23 166.75,111.23 Q8.3
N17939289: length 2.2
  TOP w0.152: D7.1 v1(177.25,107.98)
  BOTTOM w0.152: v1(177.25,107.98) 177.17,108.05 R371.1
N17941980: length 21.4
  TOP w0.254: U15.M15 v1(149.82,100.88) ; U15.M17 v1(151.42,100.88)
  L3_SIG1 w0.381: 150.81,100.28 150.81,99.86 151.41,99.26 156.69,99.26 159.99,102.57 v5(159.99,109.52) ; 150.81,100.28 v1(151.42,100.88) ; 150.81,100.28 150.39,100.28 149.82,100.86 v1(149.82,100.88)
  vias: v5(160.94,109.52)
N17943569: length 6.7
  TOP w0.152: TP32.1 156.26,93.85 154.69,95.43 153.79,95.43 153.44,95.78 153.44,97.66 153.02,98.08 U15.T19
N17947121: length 4.9
  TOP w0.152: U9.26 113.74,104.72 113.41,104.39 112.65,104.39 112.37,104.11 R122.1 R123.1
N17948726: length 5.9
  BOTTOM w0.381: R384.2 170.18,104.52 170.59,104.11 172.92,104.11 173.27,103.76 173.27,102.37 J3.4
N17968117: length 5.2
  TOP w0.152: U15.B15 149.83,109.7 149.83,110.62 149.87,110.66 149.87,110.96 151.89,112.98 R82.2
N17968119: length 4.7
  TOP w0.152: R79.2 145.8,112.78 145.12,112.11 145.12,110.72 145.01,110.6 145.01,109.68 U15.B9
N17968507: length 10.9
  TOP w0.127: v1(144.22,106.48) U15.E9
  TOP w0.152: R84.1 v1(148.84,112.88)
  L5_SIG2 w0.107: v1(148.84,112.88) 146.99,112.88 145.4,111.29 145.4,107.07 144.81,106.48 v1(144.22,106.48)
N17968518: length 4.2
  TOP w0.152: U15.A10 145.42,110.71 145.43,110.72 145.43,111.32 147.37,113.26 R85.1
N17968576: length 6.2
  TOP w0.152: U15.B16 150.6,109.66 150.86,109.66 150.86,109.67 151.17,109.67 151.44,109.93 151.44,111.53 152.07,112.17 152.6,112.17 153.54,113.11 R81.2
N17969207: length 5
  TOP w0.152: U15.B18 152.22,109.69 152.22,110.62 152.86,111.25 R97.2
N17969213: length 3.1
  TOP w0.152: R101.2 155.46,109.68 153.02,109.68 U15.B19
N17976218: length 7.8
  TOP w0.152: U15.T17 150.6,97.67 150.6,93.22 v3(150.5,93.12) 150.88,92.74 150.88,92.08 TP35.1
N17976303: length 8.2
  TOP w0.127: U15.J17 v1(151.42,104.08)
  L5_SIG2 w0.107: v1(155.51,109.02) 154.23,107.74 154.23,106.36 152.37,104.5 152.03,104.5 151.61,104.08 v1(151.42,104.08)
  BOTTOM w0.152: R375.1 v1(155.51,109.02)
N17976785: length 1.1
  BOTTOM w0.152: R379.1 C360.1
N18031730: length 4.9
  TOP w0.152: U15.G19 152.96,105.28 153.8,106.12 153.8,107.57 154.43,108.2 R105.1
N18106049: length 2.6
  TOP w0.152: U17.40 v1(85.55,99.98)
  BOTTOM w0.152: C45.2 85.58,99.95 v1(85.55,99.98)
N18116016: length 8.8
  BOTTOM w0.152: C329.1 152.28,130.3 153.07,130.3 156.99,126.38 U47.6
N18116024: length 6.9
  BOTTOM w0.152: U47.2 156.2,128.98 153.13,132.05 C328.1
N18116026: length 3.2
  BOTTOM w0.152: U47.16 151.9,129.63 150.31,131.22 R322.2
N18116030: length 7
  BOTTOM w0.152: C328.2 153.23,131.15 156.7,127.68 U47.4
N18116054: length 5.3
  BOTTOM w0.152: U47.3 159.5,128.33 159.66,128.5 159.66,129.7 160.03,130.06 160.03,130.76 160.02,130.78 C324.1
N18116066: length 2.9
  BOTTOM w0.152: C344.2 157.56,124.11 157.56,125.58 157.71,125.73 U47.7
N18116072: length 2.3
  BOTTOM w0.152: R326.2 151.03,127.38 151.38,127.03 U47.12
N18116076: length 9.4
  BOTTOM w0.152: U47.5 156.77,127.03 153.19,130.61 152.41,130.61 152.15,130.87 152.15,131.7 151.95,131.9 C329.2
N18202591: length 5.3
  TOP w0.152: U4.12 118.07,125.27 118.75,124.59 119.82,124.59 121.3,123.11 R55.1
N18238342: length 8.8
  BOTTOM w0.152: R492.1 9.53,46.74 9.29,46.5 AMC1.115
N18238353: length 9.1
  BOTTOM w0.152: R490.1 10.67,48.13 9.79,47.25 AMC1.114
N18260681: length 1.6
  BOTTOM w0.152: U45.10 R329.1
N18287363: length 13.1
  TOP w0.114: v3(168.99,135.83) 169.23,136.07 170.23,136.07 170.31,135.99 170.31,135.41 170.14,135.23 168.42,135.23 167.77,135.88 165.62,135.88 165.49,136.01 U2.4
  BOTTOM w0.114: J1.2 171.01,135.71 170.65,136.07 169.23,136.07 v3(168.99,135.83) 168.74,136.07 168.48,136.07 168.34,135.94 D13.2
N18287374: length 13.1
  TOP w0.114: v3(168.99,136.54) 169.23,136.3 169.47,136.3 169.59,136.42 169.83,136.42 169.95,136.3 170.33,136.3 170.54,136.09 170.54,135.31 170.23,135 168.33,135 167.68,135.65 167.25,135.65 167.08,135.48 166.84,135.48 166.68,135.65 166.43,135.65 166.27,135.48 166.03,135.48 165.86,135.65 165.62,135.65 165.49,135.51 U2.3
  BOTTOM w0.114: J1.3 171.59,136.3 170.46,136.3 170.29,136.47 170.05,136.47 169.88,136.3 169.23,136.3 v3(168.99,136.54) 168.74,136.3 168.48,136.3 168.34,136.44 D13.1
N18287430: length 2.5
  TOP w0.254: R6.2 163.19,139.38 U2.9
N18287465: length 6.1
  TOP w0.254: R614.2 R613.2 166.67,140.31 166.64,140.31 166.34,140.01 C3.1 165.61,138.89 164.46,137.74 U2.7
N18287912: length 4.3
  BOTTOM w0.152: U77.15 137.96,18.3 138.9,19.24 R563.1 139.5,20.02 139.57,20.08 R558.1
N18358937: length 3.4
  BOTTOM w0.102: U73.2 132.25,43.21 132.11,43.35 132.11,43.64 131.73,44.02 131.3,44.02 131.17,44.15 131.17,44.74 131.27,44.84 C732.2
N18358939: length 3.4
  BOTTOM w0.102: C733.2 130.8,44.84 130.91,44.73 130.91,44.04 131.19,43.76 131.62,43.76 131.85,43.54 131.85,43.31 131.75,43.21 U73.1
N18359019: length 3.6
  BOTTOM w0.152: U73.9 135.75,43.41 136.91,44.57 TP77.1
N18359046: length 4.2
  BOTTOM w0.152: U73.30 137.75,34.08 138.58,33.25 139.78,33.25 140.34,32.69 R551.1
N18359063: length 3.3
  BOTTOM w0.152: U73.29 138.25,34.06 138.46,33.86 140.21,33.86 TP79.1
N18359070: length 9.5
  BOTTOM w0.152: U73.33 136.25,33.45 136.71,32.99 C783.2 136.71,28.82 Y7.3
N18359080: length 6.2
  BOTTOM w0.152: Y7.1 135.45,29.33 R553.1 C784.2 135.45,32.77 135.76,33.08 135.76,34.4 135.75,34.42 U73.34
N18359169: length 2.9
  BOTTOM w0.152: C788.1 131.57,32.66 132.25,33.34 U73.41
N18359175: length 7.3
  BOTTOM w0.152: C788.2 131.57,30.71 131.88,30.4 133.58,30.4 134.04,30.86 134.04,33.3 134.25,33.51 U73.37
N18359199: length 5.3
  BOTTOM w0.152: U73.15 141.73,41.93 141.94,41.73 R508.1 142.32,42.86 142.57,43.1 R498.1
N18359263: length 2.9
  BOTTOM w0.152: TP83.1 138.46,32.94 137.25,34.15 U73.31
N18359265: length 4.5
  BOTTOM w0.152: TP85.1 138.2,31.83 138.2,32.59 136.75,34.04 U73.32
N18359267: length 3
  BOTTOM w0.152: U73.53 128.98,40.43 128.75,40.2 R514.1
N18359269: length 3.8
  BOTTOM w0.152: R500.1 129.44,43.87 129.67,43.64 129.67,42.49 130.23,41.93 U73.56
N18359271: length 2.7
  BOTTOM w0.152: U73.55 130.22,41.43 129.21,42.44 R507.1
N18359273: length 2.3
  BOTTOM w0.152: R509.1 129.14,41.02 129.23,40.93 U73.54
N18359285: length 3.1
  BOTTOM w0.152: R515.1 128.75,38.63 129.55,39.43 U73.51
N18359287: length 3.9
  BOTTOM w0.152: U73.50 129.92,38.93 129.26,38.28 129.26,36.98 129.06,36.78 R530.1
N18360107: length 5.3
  TOP w0.254: R265.2 J9.12B
N18360109: length 4.9
  TOP w0.254: J9.14B 164.34,27.04 R249.2
N18360137: length 1.9
  BOTTOM w0.508: J9.9B 155.01,23.43 C809.1
N18631752: length 1.7
  BOTTOM w0.152: C305.1 77.85,144.88 77.91,144.94 LCD1.1
N18631754: length 1.7
  BOTTOM w0.152: LCD1.2 76.41,144.94 76.45,144.9 C306.1
N18631756: length 1.7
  BOTTOM w0.152: C307.1 75.06,144.79 74.91,144.94 LCD1.3
N18631758: length 1.7
  BOTTOM w0.152: C308.1 73.66,144.69 73.41,144.94 LCD1.4
N18631760: length 1.8
  BOTTOM w0.152: C309.1 72.26,144.59 71.91,144.94 LCD1.5
N18631984: length 1.9
  BOTTOM w0.152: C301.2 70.11,144.73 70.41,145.03 LCD1.6
N18631986: length 1.9
  BOTTOM w0.152: LCD1.7 68.91,145.05 69.21,144.75 C301.1
N18631992: length 1.9
  BOTTOM w0.152: LCD1.8 67.41,144.91 67.11,144.61 C302.2
N18632005: length 1.9
  BOTTOM w0.152: LCD1.9 65.91,144.98 66.21,144.68 C302.1
N18632025: length 1.6
  BOTTOM w0.152: LCD1.10 64.39,145.64 C310.1
N18632070: length 3.5
  BOTTOM w0.152: R309.1 R308.1 64.92,140.52 65.3,140.14 Q10.1
N18638246: length 5
  BOTTOM w0.152: U76.2 43.31,34.29 42.55,33.53 R535.2
N18640521: length 4.8
  TOP w0.152: R43.1 120.96,126.31 120.52,126.75 120.52,127.81 120.22,128.12 120.22,128.65 119.84,129.04 U4.18
N18643296: length 5.7
  BOTTOM w0.102: R419.2 54.94,78.94 54.71,79.17 54.71,83.79 TP65.1
N18643297: length 2.6
  BOTTOM w0.102: TP66.1 39.88,73.84 40.08,73.63 41.58,73.63 41.71,73.76 R427.2
N18643298: length 5.7
  BOTTOM w0.102: TP64.1 54.46,83.54 54.46,79.06 54.34,78.94 R420.2
N18643299: length 2.6
  BOTTOM w0.102: TP67.1 39.88,73.23 40.03,73.38 41.63,73.38 41.71,73.3 R430.2
N18643300: length 11.4
  TOP w0.102: R206.2 82.04,74.75 82.14,74.65 83.94,74.65 84.07,74.78 92.41,74.78 92.51,74.88 TP42.1
N18643301: length 11.4
  TOP w0.102: TP43.1 92.51,74.42 92.41,74.52 84.18,74.52 84.05,74.4 82.12,74.4 82.04,74.32 R210.2
N18643419: length 1.4
  TOP w0.152: R173.2 45.21,86.23 TP36.1
N18643442: length 2.7
  TOP w0.152: R174.2 46.28,85.21 44.45,85.21 TP37.1
N18643465: length 4.8
  BOTTOM w0.152: TP81.1 86.08,33.45 86.08,34.51 86.21,34.64 86.21,34.96 86.08,35.08 86.08,35.49 86.64,36.05 R521.2
N18643488: length 1.7
  BOTTOM w0.152: R534.2 TP80.1
N18643523: length 2.3
  BOTTOM w0.152: R433.2 42.67,71.81 TP68.1
N18643546: length 6.2
  BOTTOM w0.152: TP74.1 38.86,53.29 41.17,53.29 42.6,54.71 R473.2
N18643624: length 2.2
  BOTTOM w0.152: R461.2 37.8,63.5 TP71.1
N18643711: length 1.2
  TOP w0.152: TP55.1 R237.2
N18643735: length 1.2
  TOP w0.152: TP53.1 92.71,34.85 R236.2
N18643759: length 1.7
  BOTTOM w0.152: TP69.1 42.47,70.74 R437.2
N18643843: length 12.6
  TOP w0.152: TP47.1 90.5,65.28 R214.2
N18646931: length 1.5
  TOP w0.152: R121.2 TP29.1
N18646952: length 1.5
  TOP w0.152: TP31.1 R124.2
N18646958: length 1.5
  TOP w0.152: R119.2 TP27.1
N18646969: length 1.5
  TOP w0.152: R120.2 TP28.1
N18661122: length 4.2
  TOP w0.254: R156.1 155.12,97.98 U15.N19
N18690585: length 4.9
  BOTTOM w0.152: C661.1 R471.1 U67.7 118.11,57.54 117.98,57.4 117.98,57.15 118.1,57.03 U67.8
N18909283: length 4.9
  TOP w0.152: R95.2 R88.1 62.3,114.56 v1(62.05,114.81)
  BOTTOM w0.102: U53.G5 63.89,114.32 62.51,114.32 62.29,114.54 62.29,114.55 62.05,114.78 v1(62.05,114.81)
N19595154: length 30.3
  TOP w0.127: 68.38,47.32 U23.J33
  TOP w0.152: TP56.1 R238.1 88.88,35.85 89.61,36.58 89.61,39.32 82.98,45.95 69.68,45.95 68.38,47.26 68.38,47.32
N19595193: length 30.9
  TOP w0.127: 69.18,47.32 U23.H33
  TOP w0.152: TP54.1 91.41,34.92 R243.1 90.78,36.46 90.78,39.73 83.95,46.56 69.94,46.56 69.18,47.32
N19595213: length 35.6
  TOP w0.152: U23.K29 v6(67.98,50.96)
  BOTTOM w0.152: v6(67.98,50.96) 68.38,50.55 68.38,50.33 68.38,50.32 68.38,50 68.38,49.99 68.38,49.53 68.38,49.52 68.38,49.2 68.38,49.19 68.38,47.71 69.49,46.61 75.75,46.61 76.46,47.32 82.37,47.32 85.24,44.45 R522.1 85.8,37.36 85.8,36.25 85.47,35.91 85.11,35.91 84.68,35.48 84.68,33.73 TP82.1
N19617731: length 5
  TOP w0.152: U20.9 146.7,80.4 147.12,79.98 R199.2 147.12,78.88 147.45,78.56 R202.2 C100.2
N19618957: length 4.3
  TOP w0.152: U20.11 146.82,81.4 146.93,81.52 147.78,81.52 148.02,81.27 R196.1 148.41,80.9 148.52,81.01 R194.1
N19619378: length 4.5
  TOP w0.254: U20.14 144.39,83.57 144.6,83.77 R185.1 144.6,84.75 145.09,85.24 R180.2
N19620431: length 2
  TOP w0.152: R203.1 146.05,78.18 144.9,79.33 U20.8
N19620706: length 5.7
  TOP w0.152: U20.1 141.24,81.9 140.97,82.17 140.97,83.31 v3(140.34,83.95) R191.1
  BOTTOM w0.152: R191.1 v3(140.34,83.95)
N19620742: length 4.8
  TOP w0.152: R192.1 v3(140.21,82.55) 140.21,82.17 140.97,81.4 U20.2
  BOTTOM w0.152: v3(140.21,82.55) R192.1
N19627767: length 4.2
  TOP w0.152: Y5.3 56.96,90.36 57.2,90.6 57.2,91.62 57.47,91.89 C58.2 58.56,91.89 58.85,91.61 R167.1
N19627773: length 6.4
  TOP w0.152: R164.1 57.93,93.13 C54.2 54.09,93.15 53.76,93.48 Y5.1
N19628918: length 4.3
  TOP w0.152: Y4.3 56.84,96.2 57.15,95.89 58.6,95.89 59.04,95.45 R163.1
N19630686: length 4.6
  BOTTOM w0.102: C897.1 31.45,41.08 31.32,40.94 31.32,39.87 R677.2 31.29,39.2 31.29,37.93 31.37,37.86 U75.44
N19630689: length 4.6
  BOTTOM w0.102: U75.43 30.97,37.86 31.04,37.93 31.04,39.25 R677.1 31.06,39.87 31.06,40.94 30.93,41.08 C898.1
N19642467: length 2.9
  BOTTOM w0.152: U58.6 49.46,94.59 49.75,94.3 50.11,94.3 50.65,94.84 R390.1
N19665402: length 5
  TOP w0.152: U19.3 153.61,89.89 153.87,89.63 v1(156.15,89.63)
  BOTTOM w0.152: v1(156.15,89.63) 155.95,89.43 U59.4
N19666056: length 2.4
  TOP w0.152: C68.1 152.54,88.41 152.77,88.63 U19.4
N19669080: length 2.4
  TOP w0.152: U11.8 90.84,108.59 v3(91.17,108.92)
  BOTTOM w0.152: R378.1 90.84,108.58 v3(91.17,108.92)
N19695800: length 4.1
  BOTTOM w0.381: U32.4 154.41,51.96 R245.1 R246.2 153.2,51.94 U31.4
N19714193: length 5.1
  TOP w0.102: J10.6 30.29,20.72 30.8,21.23 30.8,24.13 30.67,24.26 C242.1
N19714195: length 5.1
  TOP w0.102: J10.5 31.56,20.72 31.05,21.23 31.05,24.16 31.16,24.26 C241.1
N19714197: length 5.1
  TOP w0.102: C240.1 34.48,24.26 34.61,24.13 34.61,21.22 34.1,20.71 J10.3
N19714199: length 5.1
  TOP w0.102: C239.1 34.95,24.26 34.86,24.18 34.86,21.22 35.37,20.71 J10.2
N19809600: length 3.9
  TOP w0.152: R57.1 118.32,123.11 118.11,123.32 118.11,124.1 117.07,125.15 U4.10
N19815748: length 5.3
  TOP w0.254: v2(150.88,55.5) 150.87,55.5 R533.2
  BOTTOM w0.254: U31.2 v2(150.88,55.5)
  BOTTOM w0.381: R246.1 151.95,52.85 150.88,53.92 U31.2
N19819673: length 5.3
  TOP w0.254: R223.2 R220.1 159.06,33.18 159.01,33.13 U27.2
N19956937: length 5.8
  TOP w0.152: U9.16 v1(107.95,112.45)
  BOTTOM w0.152: R354.1 R356.2 109.15,114.2 107.95,113 v1(107.95,112.45)
N19977415: length 6.3
  TOP w0.152: U17.26 88.1,92.62 88.17,92.56 89.11,92.56 89.53,92.13 89.53,90.07 89.28,89.81 88.6,89.81 88.24,89.46 88.24,89.08 88.42,88.89 R674.1
N19977416: length 6.1
  TOP w0.152: U17.25 87.93,92.12 87.99,92.18 89.05,92.18 89.23,92 89.23,90.19 89.15,90.12 88.47,90.12 87.93,89.59 87.93,89.03 87.8,88.89 R675.1
N20100474: length 1.8
  TOP w0.152: U3.6 104.59,132.97 105.51,132.05 R20.1
N20108296: length 5
  BOTTOM w0.152: R415.2 R417.1 162.12,81.63 161.8,81.31 U61.4
N20256439: length 1.8
  TOP w0.114: C186.1 156.28,61.58 arc(156.37,61.78) 156.57,61.86 156.9,61.86 arc(157.27,61.79) L9.2
N20256446: length 1.8
  TOP w0.114: C189.1 156.28,62.37 arc(156.37,62.17) 156.57,62.09 156.9,62.09 arc(157.27,62.16) L9.1
N20256822: length 1.7
  TOP w0.114: C126.1 165.75,48.94 arc(165.85,49.17) 166.07,49.26 166.23,49.26 arc(166.6,49.18) L4.2
N20259025: length 3.7
  TOP w0.254: R165.1 44.96,93.6 45.47,94.11 TP33.1
N20259028: length 28
  TOP w0.152: U23.AE4 v6(55.18,71.76)
  TOP w0.254: v1(46.9,92.99) 46.78,92.99 46.06,92.26 R165.2
  L10_SIG4 w0.107: v6(55.18,71.76) 55.18,72.05 55.04,72.19 55.02,72.19 54.74,72.47 54.74,73.88 46.94,81.69 46.94,85.8 47.52,86.39 47.52,92.36 v1(46.9,92.99)
N20260067: length 39.6
  TOP w0.152: U23.AL32 v6(50.38,48.56)
  L3_SIG1 w0.102: v1(22.66,56.01) 21.69,55.04 21.69,49.63 24,47.33 39.28,47.33 39.96,46.65 41.37,46.65 42.14,47.42 47.35,47.42 48.08,48.16 49.97,48.16 v6(50.38,48.56)
  BOTTOM w0.152: U68.4 v1(22.66,56.01)
N20260083: length 36.2
  TOP w0.152: U23.AM32 v6(49.58,48.56)
  L3_SIG1 w0.102: v1(22.33,54.91) 22.33,49.81 23.71,48.43 39.96,48.43 40.78,49.25 47.88,49.25 48.16,48.97 49.16,48.97 v6(49.58,48.56)
  BOTTOM w0.152: v1(22.33,54.91) 22.77,55.36 U68.5
N20260360: length 2.1
  BOTTOM w0.152: U68.8 17.56,54.06 17.47,53.98 R475.1
N20314517: length 2.2
  BOTTOM w0.152: R487.2 26.09,50.29 25.87,50.07 U70.7
N20314549: length 3
  BOTTOM w0.152: U70.6 26.13,50.72 26.47,51.06 R483.2
N20314831: length 2.5
  BOTTOM w0.152: R499.2 26.62,43.94 26.17,43.49 U72.7
N20314842: length 3.1
  BOTTOM w0.152: U72.6 26.09,44.14 26.98,45.03 R495.2
N20315949: length 2.6
  BOTTOM w0.152: R482.2 18.33,52.07 18.64,51.77 U70.4
N20316135: length 8.9
  BOTTOM w0.152: U72.4 20.05,44.79 20.45,44.39 20.45,41.78 18.52,39.85 R513.2
N20339426: length 25.1
  TOP w0.152: U23.P31 v6(64.78,49.36)
  BOTTOM w0.152: R541.1 79.9,35.25 80.19,35.54 80.19,36.58 80.29,36.68 80.29,38.17 79.52,38.93 78.84,38.93 73.3,44.48 67.93,44.48 64.78,47.63 v6(64.78,49.36)
N20339428: length 23.6
  TOP w0.152: U23.R29 v6(63.98,50.96)
  BOTTOM w0.152: v6(63.98,50.96) 64.38,50.55 64.38,47.59 67.8,44.17 73.17,44.17 78.72,38.63 79.37,38.63 79.65,38.35 R526.1
N20339430: length 23.4
  TOP w0.127: U23.P33 64.38,47.32
  TOP w0.152: R233.1 80.39,37.24 80.11,37.52 78.18,37.52 74.3,41.4 74.3,43.54 73.73,44.1 66.49,44.1 64.38,46.22 64.38,47.32
N20339432: length 29.5
  TOP w0.152: U23.L30 v6(67.18,50.16)
  BOTTOM w0.152: R524.1 82.45,39.21 83.95,40.71 83.95,44.02 81.86,46.1 76.96,46.1 76.25,45.39 68.63,45.39 66.78,47.24 66.78,49.19 66.78,49.2 66.78,49.52 66.78,49.53 66.78,49.77 v6(67.18,50.16)
N20339434: length 25
  TOP w0.152: U23.R31 v6(63.98,49.36)
  BOTTOM w0.152: R542.1 78.92,35.91 78.92,37.98 73.03,43.87 67.08,43.87 63.58,47.37 63.58,48.97 v6(63.98,49.36)
N20339438: length 22.5
  TOP w0.127: 66.78,47.32 U23.L33
  TOP w0.152: R232.1 81.79,37.29 80.95,38.13 78.43,38.13 74.9,41.65 74.9,43.92 74.09,44.73 68.33,44.73 66.78,46.28 66.78,47.32
N20460479: length 4.9
  BOTTOM w0.152: U69.8 118.1,51.19 117.98,51.31 117.98,51.56 118.11,51.69 U69.7 R484.1 C724.1
N20517788: length 3.3
  BOTTOM w0.152: EEPROM1.3 120.92,74.68 121.17,74.42 R425.1 R429.2
N20517790: length 3.3
  BOTTOM w0.152: EEPROM1.2 R422.1 R421.2
N20589689: length 29.5
  TOP w0.152: TP59.1 79.88,32.51 v1(80.26,32.89) ; U23.L29 v6(67.18,50.96)
  L8_SIG3 w0.107: v1(80.26,32.89) 80.26,36.55 79.86,36.96 78.25,36.96 73.81,41.4 72.14,41.4 71.45,42.09 71.45,43.3 69.88,44.87 69.88,48.85 69.95,48.92 69.95,51.31 69.87,51.39 67.6,51.39 v6(67.18,50.96)
N20589690: length 28.7
  TOP w0.152: TP60.1 77.98,32.64 78.36,33.02 v1(79.63,33.02) ; U23.M29 v6(66.38,50.96)
  L8_SIG3 w0.107: v6(66.38,50.96) 66.76,50.57 69.01,50.57 69.15,50.43 69.15,45.28 70.71,43.71 70.71,43.33 71.12,42.93 71.12,40.61 71.73,40 71.73,39.47 78.18,33.02 v1(79.63,33.02)
N20589691: length 25.5
  TOP w0.127: 67.18,47.32 67.18,47.99 67.18,48.56 U23.L32
  TOP w0.152: 67.18,47.32 67.18,46.74 68.88,45.03 74.22,45.03 75.21,44.04 75.21,41.78 78.56,38.43 81.33,38.43 82.37,37.39 TP57.1
N22090512: length 3.7
  TOP w0.254: R275.2 68.96,4.22 68.7,4.48 66.91,4.48 66.5,4.89 U34.40
N22090514: length 2.1
  TOP w0.254: U34.25 61.33,9.51 v5(61.06,9.78)
  BOTTOM w0.381: v5(61.06,9.78) 61.1,9.74 C842.1
  vias: v4(43.84,7.42) v4(43.84,6.02) v4(45.24,7.42) v4(45.24,6.02) v4(46.63,7.42) v4(46.63,6.02)
N22090530: length 3.5
  TOP w0.254: U34.35 v3(64,4.32)
  BOTTOM w0.254: v3(64,4.32) 64.32,4.64 C858.2 C857.2
N22090531: length 1.4
  BOTTOM w0.254: R592.1 64.83,3.02 64.9,3.09 C858.1
N22090532: length 18.1
  TOP w0.254: U34.34 63.5,4.69 63.17,4.37 v3(63.02,4.37) 62.61,4.37 62.18,3.94 R603.2
  BOTTOM w0.254: R592.2 65.73,3.21 66.26,3.74 C857.1 67.03,3.74 67.12,3.83 67.12,5.02 66.95,5.19 63.83,5.19 v3(63.02,4.37) 63.02,3.56 62.03,2.58 R593.1 62.03,2.09 61.72,1.78 60.23,1.78 60,2.01 R594.2 60,3.49 60.25,3.74 R587.1
N22090538: length 2.8
  TOP w0.305: U34.33 v3(62.1,5.29)
  BOTTOM w0.254: v3(62.1,5.29) C859.2 R587.2
N22090539: length 1.9
  BOTTOM w0.254: R594.1 61.09,2.41 62.1,3.43 C859.1
N22090556: length 3.1
  TOP w0.254: U34.36 64.5,3.88 63.98,3.37 R280.2
N22090558: length 1.6
  TOP w0.254: U33.4 96.82,13.77 96.57,14.02 ; U33.2 96.59,14.77
N22090568: length 4.1
  TOP w0.254: v3(101.55,5.37) 101.55,5.73 C283.1 102.56,6.73 102.56,9.05 U33.22
  vias: v4(83.19,14.73) v4(83.19,13.34) v4(84.45,14.73) v4(84.45,13.34) v4(111.12,13.34) v4(112.39,13.34)
N22090580: length 5.7
  TOP w0.254: C246.1 98.39,21.16 98.53,21.01 R257.2 R261.2 98.54,18.84 U33.47
N22090592: length 2.5
  TOP w0.254: U33.12 97.34,8.82 97.09,8.57 C278.1
N22090599: length 5.1
  TOP w0.254: U33.28 105.44,11.27 105.61,11.1 105.61,8.31 105.94,7.98 C280.1
N22090604: length 4.6
  TOP w0.254: U33.33 105.42,13.77 105.64,14 105.64,16.23 105.99,16.58 C254.1
N22090609: length 6.3
  TOP w0.254: C290.1 R273.2 R269.2 97.61,6.92 98.54,7.86 U33.14
N22090615: length 8.9
  TOP w0.254: C292.1 R274.2 R270.2 106.3,5.89 106.47,6.06 106.47,6.89 105.03,8.33 105.03,10.04 104.8,10.27 U33.26
N22090621: length 8.3
  TOP w0.254: C245.1 R256.2 R260.2 104.42,18.75 105.49,17.68 105.49,16.99 105.11,16.61 105.11,15.09 104.79,14.77 U33.35
N22090627: length 1.8
  TOP w0.254: U33.45 v3(99.54,16.92)
  BOTTOM w0.254: C830.1 99.73,16.5 99.54,16.69 v3(99.54,16.92)
N22090640: length 4.9
  TOP w0.254: v3(99.12,18.34) 99.12,17.48 99.04,17.4 U33.46
  BOTTOM w0.254: R561.1 C823.1 98.53,18.68 99.01,18.2 99.05,18.23 99.05,18.34 v3(99.12,18.34)
N22090648: length 1.4
  BOTTOM w0.254: C821.2 96.88,20.24 R561.2
N22090649: length 6.1
  TOP w0.254: C295.1 99.26,3.93 99.6,4.27 99.6,7.81 99.54,7.87 U33.16
N22090650: length 2.6
  TOP w0.254: v3(103.78,8.03) 103.54,8.27 U33.24
  BOTTOM w0.381: C843.1 103.56,8.32 103.78,8.1 v3(103.78,8.03)
N22090651: length 4.1
  TOP w0.254: v3(103.07,18.01) 103.54,17.54 U33.37
  BOTTOM w0.254: v3(103.07,18.01) 102.55,17.49 102.55,16.82 C829.1
N22090653: length 2.1
  TOP w0.254: U33.40 v3(102.04,17.02)
  BOTTOM w0.254: v3(102.04,17.02) 101.59,17.02 101.47,16.9 R569.1
N22090664: length 2.3
  TOP w0.254: C256.1 96.91,16.25 97.34,15.82 U33.1
N22090666: length 2.6
  TOP w0.254: v3(103.25,7.37) 103.04,7.58 U33.23
  BOTTOM w0.381: v3(103.25,7.37) 103.32,7.44 R575.2
N22090676: length 6.4
  TOP w0.254: v3(99.12,7.61) 99.04,7.69 U33.15
  BOTTOM w0.254: v3(99.12,7.61) 98.71,7.2 97.25,7.2 96.7,6.65 C851.2 R586.1
N22090680: length 2
  TOP w0.254: v3(98.28,5.21) 98.33,5.26 C282.2
  BOTTOM w0.254: R586.2 97.61,5.08 97.73,5.21 v3(98.28,5.21)
N22090686: length 3.4
  TOP w0.254: v3(104.99,6.86) 104.29,6.86 103.63,6.2 C284.2
  BOTTOM w0.254: v3(104.99,6.86) 105.11,6.73 R582.2
N22090687: length 6
  TOP w0.254: v3(105.89,6.63) 105.47,7.05 105.47,7.06 104.24,8.28 U33.25
  BOTTOM w0.152: v3(105.89,6.63) 106.01,6.5 R582.1
  BOTTOM w0.254: R582.1 C856.2
N22090695: length 1.5
  BOTTOM w0.254: R560.2 105.54,20.45 105.98,20.01 C820.2
N22090696: length 5.7
  TOP w0.254: U33.36 104.24,16.69 v3(104.9,17.36)
  BOTTOM w0.254: R560.1 C822.1 104.2,18.87 104.9,18.16 v3(104.9,17.36)
N22090791: length 2.8
  TOP w0.254: v3(102.21,17.86) 102.21,17.85 102.54,17.53 U33.39
  BOTTOM w0.254: v3(102.21,17.86) 101.96,17.6 R567.2
N22090797: length 1.9
  TOP w0.254: U35.6 51.59,3.74 51.38,3.95 v3(51.38,4.24)
  BOTTOM w0.305: R590.2 51.57,3.74 51.38,3.93 v3(51.38,4.24)
N22090840: length 3.2
  TOP w0.254: R272.2 100.33,7.12 100.04,7.42 U33.17
N22090844: length 6.1
  TOP w0.254: U34.4 v3(68.12,7.51)
  BOTTOM w0.254: v3(68.12,7.51) 68.12,6.68 69.19,5.61 71.19,5.61 71.69,5.12 R583.2
N22090845: length 3.7
  TOP w0.254: U34.5 68.57,8.01 v3(68.67,7.91)
  BOTTOM w0.254: v3(68.67,7.91) 68.67,6.76 69.08,6.35 R580.2
N22090846: length 4.4
  TOP w0.254: v3(68.02,5.46) 68.02,5.82 67.82,6.01 U34.1
  BOTTOM w0.254: v3(68.02,5.46) 68.53,4.95 R584.2 R589.2
N22090848: length 2.8
  TOP w0.254: U34.6 69.01,8.51 v3(69.14,8.38)
  BOTTOM w0.254: v3(69.14,8.38) 69.16,8.38 69.19,8.36 69.19,8.36 69.53,8.02 R577.2
N22090854: length 3.3
  TOP w0.254: U33.43 100.54,18.49 100.23,18.8 R259.2
N22090856: length 4.3
  TOP w0.254: R258.2 102.01,18.59 v3(101.75,18.34) 101.54,18.12 U33.41
  BOTTOM w0.254: v3(101.75,18.34) 102.01,18.59 R258.2
N22090858: length 6.1
  TOP w0.254: R255.2 100.78,21.42 101.04,21.16 U33.42
N22090866: length 2.5
  TOP w0.254: U34.30 61.17,7.01 60.65,6.5 R268.2
N22090868: length 2
  TOP w0.254: U34.37 65,4.77 64.97,4.75 64.97,4.04 64.88,3.94 64.88,3.63 64.87,3.63 R279.1
N22090880: length 7.1
  TOP w0.254: U33.44 100.04,18.39 99.04,19.38 99.04,22.6 TP63.1
N22090898: length 2.3
  TOP w0.254: U34.3 R266.2
N22090899: length 2.7
  TOP w0.254: R271.2 69.08,5.62 68.19,6.51 U34.2
N22090903: length 3.7
  TOP w0.254: R277.1 R278.1 66.93,3.76 66,4.69 U34.39
N22090947: length 7.2
  TOP w0.254: C281.1 60.2,6.54 61.17,7.51 U34.29
  TOP w0.508: R267.1 57.47,6.48 C281.1
N22090970: length 2.8
  TOP w0.254: U33.38 v3(103.04,17.14)
  BOTTOM w0.254: R566.2 104.25,16.93 104.04,17.14 v3(103.04,17.14)
N22169052: length 1.2
  TOP w0.152: U23.L26 v6(67.18,53.36)
  BOTTOM w0.127: R477.1 v6(67.18,53.36)
N22169056: length 1.2
  TOP w0.152: U23.K26 v6(67.98,53.36)
  BOTTOM w0.127: R478.1 v6(67.98,53.36)
N24344484: length 1.6
  BOTTOM w0.152: R389.2 U57.9
N24344504: length 1.6
  BOTTOM w0.152: U57.7 R387.2
N24344573: length 1.6
  BOTTOM w0.152: U57.1 R385.2
N24344575: length 2.4
  BOTTOM w0.152: U57.19 93.75,104.55 92.3,104.55 92.12,104.36 R386.2
N25551345: length 6.9
  TOP w0.127: 142.62,110.85 142.62,109.96 143.02,109.56 U15.B7
  TOP w0.152: v1(140.66,114.24) 141.19,114.24 141.69,113.73 141.69,112.35 142.62,111.41 142.62,110.85
  BOTTOM w0.152: R283.2 v1(140.66,114.24)
N25551369: length 7.8
  TOP w0.127: U15.D8 v1(143.42,108.08)
  BOTTOM w0.127: 142.62,110.85 142.62,110.24 143.81,109.05 143.81,108.48 v1(143.42,108.08)
  BOTTOM w0.152: R476.2 141.16,113.54 141.74,112.95 141.74,112.09 142.62,111.21 142.62,110.85
N25551410: length 4.8
  TOP w0.127: U15.A16 150.22,110.62 150.44,110.85
  TOP w0.152: 150.44,110.85 v6(150.79,111.19)
  BOTTOM w0.152: R596.2 149.08,113.4 149.47,113.01 149.47,112.51 v6(150.79,111.19)
N25551640: length 5
  TOP w0.127: 151.82,110.85 U15.A18
  TOP w0.152: 151.82,110.85 151.82,111.1 v6(152.13,111.42)
  BOTTOM w0.152: v6(152.13,111.42) 151.71,111.84 151.71,112.65 150.96,113.4 R597.2
N25565163: length 11.7
  TOP w0.127: U15.A9 144.62,110.55 144.82,110.76 144.82,110.85
  TOP w0.152: 144.82,110.85 144.82,112.05 v1(144.62,112.25)
  BOTTOM w0.152: v1(144.62,112.25) 144.45,112.42 144.45,116.71 143.87,117.29 141,117.29 140.66,116.95 R481.2
N25619366: length 4.1
  TOP w0.127: U15.C8 v1(143.42,108.88)
  BOTTOM w0.152: v1(143.42,108.88) 142.08,110.22 141.18,110.22 R599.2
N25619369: length 2.6
  TOP w0.127: 141.09,110.85 141.09,110.7 141.42,110.38 U15.A5
  TOP w0.152: v6(141.09,111.48) 141.09,110.85
  BOTTOM w0.152: R600.2 140.98,112.14 141.09,112.03 v6(141.09,111.48)
N26224346: length 9.2
  TOP w0.254: TP94.1 107.14,2.49 v3(107.14,3.71)
  BOTTOM w0.254: R575.1 104.01,6.56 104.94,7.49 106.5,7.49 106.71,7.29 106.71,4.14 v3(107.14,3.71)
N26374725: length 1.3
  BOTTOM w0.254: R623.2 C874.2
N26377331: length 1.4
  BOTTOM w0.152: R621.2 C872.2
N26444584: length 3.9
  BOTTOM w0.152: R628.2 141.6,123.75 139.88,123.75 139.7,123.93 U79.6
N26449108: length 6.3
  BOTTOM w0.381: Q15.3 143.01,24.84 142.44,25.4 142.44,27.06 R647.2 R648.1
N26465222: length 5.3
  BOTTOM w0.152: R407.1 45.66,95.82 45.85,95.63 46.74,95.63 47.28,95.08 47.28,93.76 47.46,93.59 U58.8
N26465374: length 4.4
  BOTTOM w0.152: U58.1 44.35,93.59 43.6,92.84 42.04,92.84 41.66,93.22 R412.1
N26504675: length 1.9
  TOP w0.152: R94.2 U8.21
N26504706: length 2.3
  TOP w0.152: R93.1 69.86,113.23 69.98,113.34 U8.8
N26537188: length 1.1
  BOTTOM w0.254: R653.2 C896.2
N26540501: length 2.3
  BOTTOM w0.152: R642.2 43,90.58 43.1,90.68 43.9,90.68 44.22,91.01 U80.22
N26541964: length 1.5
  BOTTOM w0.152: U80.14 43.26,87.01 R655.2
N26588297: length 1.4
  BOTTOM w0.152: U80.6 49.24,89.51 R637.1
N26588299: length 4.1
  BOTTOM w0.152: R636.1 51.49,89.92 51.27,90.14 49.49,90.14 49.35,90.01 U80.5
N26588301: length 1.4
  BOTTOM w0.152: R635.1 49.16,90.51 U80.4
N26588303: length 3.7
  BOTTOM w0.152: U80.3 48.83,91.01 49.53,91.7 R634.1
N26588305: length 2.5
  BOTTOM w0.152: U80.9 48.9,88.01 49.02,87.88 49.02,87.38 49.46,86.94 R640.1
N26588307: length 4.1
  BOTTOM w0.152: R638.1 51.49,88.44 51.21,88.72 49.15,88.72 48.87,89.01 U80.7
N26588309: length 1.7
  BOTTOM w0.152: R639.1 49.46,88.16 49.28,88.34 49,88.34 48.84,88.51 U80.8
