# Allegro board TI_K2E_EVM_PCB_17-00175-03.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_3: length 12.9
  TOP w0.254: v3(110.94,127) 110.98,127.04 U4.47 ; v3(111.51,133.35) 112.14,133.35 112.57,132.93 U4.36
  BOTTOM w0.381: v3(108.64,123.9) 110.94,126.2 v3(110.94,127) 111.53,127.59 111.53,133.33 v3(111.51,133.35)
  vias: v3(107.82,123.9)
GND_LAN: length 32.7
  TOP w0.508: J9.SH3 175.3,27.61 ; J9.SH3 175.3,29.49 ; J9.SH3 173.41,29.49 ; J9.SH1 175.3,10.6 ; J9.SH1 175.3,12.48 ; J9.SH1 173.41,10.6
  L8_SIG3 w0.381: 152.95,18.73 J9.10A ; J9.10A 154.36,18.73 ; J9.10A 152.95,17.31 ; J9.SH1 175.3,10.6 ; J9.SH1 175.3,12.48 ; J9.SH1 173.41,10.6 ; 153.35,12.48 J9.SH2 ; J9.SH2 155.24,12.48 ; J9.SH2 153.35,10.6 ; J9.SH2 155.24,10.6 ; J9.SH4 159.3,27.61 ; J9.SH4 157.41,29.49 ; J9.SH4 159.3,29.49 ; J9.SH4 157.41,27.61 ; 173.41,29.49 J9.SH3 ; J9.SH3 175.3,27.61 ; J9.SH3 175.3,29.49 ; J9.10B 154.36,21.37 ; J9.10B 152.95,22.79 ; J9.10B 152.95,21.37
GND_USB: length 21.9
  TOP w0.381: v3(167.39,134.9) 168.44,133.86 174.4,133.86 175.39,132.86 J1.6
  BOTTOM w0.254: D13.4 v3(167.39,134.9)
  BOTTOM w0.381: 175.33,141.19 J1.7 ; J1.7 178.37,141.19 ; J1.7 175.33,139.13 ; 175.33,133.89 J1.6 ; J1.6 175.33,131.83 ; J1.6 178.37,131.83
VBAT: length 15.7
  TOP w0.254: 149,133.16 U1.55
  TOP w0.381: CN1.2 155.91,137.8 153.9,135.79 152.27,135.79 152,135.52 C10.1 152,134.47 152.34,134.14 OSC1.4 OSC1.1 150.87,133.51 149.35,133.51 149,133.16
VBUS0: length 120.9
  TOP w0.254: v5(159.44,58.7) C164.1 157.86,57.84 U29.A1
  L10_SIG4 w0.254: v1(136.65,58.98) 137.49,59.82 146.91,59.82 147.09,59.64 158.5,59.64 v5(159.44,58.7)
  BOTTOM w0.381: v1(136.65,58.98) 129.39,58.98 127,61.37 127,75.56 124.03,78.54 113.29,78.54 112.79,79.04 112.2,79.04 105.59,85.66 105.59,92.05 105.03,92.61 103.76,92.61 103.23,92.08 98.98,92.08 97.1,93.95 94.29,93.95 93.42,93.09 93.42,81.76 85.72,74.07 R426.1
VBUS0_R: length 27.8
  TOP w0.152: U23.W5 v6(59.98,70.96)
  BOTTOM w0.152: 75.5,73.77 72.63,73.77 72.38,73.52 72.38,70.81 72.13,70.55 62.21,70.55 61.96,70.8 61.96,71.07 61.68,71.35 60.37,71.35 v6(59.98,70.96)
  BOTTOM w0.381: 75.5,73.77 81.72,73.77 82.02,74.07 R426.2
VBUS1: length 132.4
  TOP w0.254: C151.1 152.92,34.13 U28.A1
  TOP w0.381: C151.1 v3(151.58,35.71)
  BOTTOM w0.381: R424.1 85.78,75.46 92.68,82.37 92.68,93.4 93.95,94.67 97.31,94.67 99.19,92.79 102.84,92.79 103.35,93.29 107.62,93.29 109.68,91.24 109.68,83.79 114.19,79.28 124.68,79.28 127.66,76.3 127.66,62.61 128.83,61.44 141.45,61.44 143.36,59.54 143.36,49.28 152.29,40.35 152.29,38.39 151.31,37.41 151.31,35.98 v3(151.58,35.71)
VBUS1_R: length 27.2
  TOP w0.254: U23.V4 v6(60.78,71.76)
  BOTTOM w0.152: 71.58,74.83 71.58,71.61 71.34,71.37 62.21,71.37 61.82,71.76 v6(60.78,71.76)
  BOTTOM w0.381: R424.2 71.88,75.46 71.58,75.17 71.58,74.83
VCC0V75: length 130.7
  TOP w0.254: v3(105.92,121.21) 105.92,125.68 106.6,126.36 R41.2 ; v3(118.41,36.9) 110.82,36.9 109.6,35.69 v5(109.6,34.06)
  TOP w0.381: DIMM1.204 107.33,29.27 107.57,29.03 ; DIMM1.203 96.67,29.57 96.11,29.01
  L3_SIG1 w0.254: v3(105.92,121.21) 105.92,115.73 110.76,110.9 115.94,110.9 116.61,110.23 116.61,103.82 117.58,102.84 117.58,97.44 123.95,91.07 123.95,47.12 123.11,46.28 120.07,46.28 118.85,45.06 117.31,45.06 113.08,40.83 113.08,36.95 110.19,34.06 v5(109.6,34.06)
  BOTTOM w0.254: U74.5 v3(118.41,36.9)
  BOTTOM w0.279: U74.3 117.17,35.2
  vias: v3(95.26,27.76) v3(95.26,26.87) v3(96.15,27.76) v3(96.15,26.87) v3(107.07,28.42) v3(107.07,27.53) v3(107.96,28.42) v3(107.96,27.53) v5(109.6,32.92) v5(111,34.06) v5(111,32.92) v5(112.34,34.09) v5(112.34,32.94)
VCC0V75_EN: length 111.4
  TOP w0.152: R12.2 v1(119.23,135.96)
  L5_SIG2 w0.254: v3(123.02,37.92) 119.2,41.74 119.2,97.71 118.32,98.59 118.32,113.57 119.96,115.21 119.94,115.23 119.94,122.06 118.64,123.37 115.79,123.37 115.11,124.05 115.11,125.03 115.74,125.66 117.92,125.66 119.23,126.97 v1(119.23,135.96)
  BOTTOM w0.152: v3(123.02,37.92) R529.2 123.02,36.48 122.72,36.18 122.71,36.18 122.24,35.7 U74.7
VCC0V75_MON: length 3.2
  TOP w0.152: U4.45 110.67,128.04 109.67,127.04 R41.1
VCC0V75REF: length 130.1
  TOP w0.254: DIMM1.84 107.04,65.27 v3(107.67,65.9) ; U23.F15 v6(71.18,62.96)
  TOP w0.305: DIMM1.1 C57.2 94.56,93.06 94.72,93.23 v3(94.72,93.19)
  BOTTOM w0.152: 75.89,62.57 72.61,62.57 72.38,62.8 72.38,63.11 72.13,63.37 71.58,63.37 v6(71.18,62.96)
  BOTTOM w0.178: 75.89,62.57 76.07,62.38
  BOTTOM w0.254: C576.1 v6(71.18,62.96) ; U74.6 122.03,36.2 ; 76.07,62.38 77.83,60.63 85.87,60.63 89.76,64.52 104.65,64.52 105.44,65.3 C531.1 C530.2 v3(107.67,65.9)
  BOTTOM w0.381: C57.2 94.56,93.03 v3(94.72,93.19)
  BOTTOM w0.508: v5(122.96,40.18) 124.08,40.18 125.63,41.73 125.63,45.62 123.88,47.36 123.88,57.66 121.55,59.99 118.16,59.99 117.37,60.78 117.37,65.02 115.75,66.65 108.45,66.65 107.97,66.17 107.93,66.17 v3(107.67,65.9)
  BOTTOM w0.635: 108.45,66.65 108.45,66.65 108.45,69.28 107.57,70.15 98.7,70.15 98.04,70.82 98.04,91.82 96.67,93.19 v3(94.72,93.19)
  vias: v5(121.82,41.2) v5(122.96,41.08) v5(122.96,39.17)
VCC0V85: length 234
  TOP w0.254: R62.2 111.09,122.21 v3(110.74,122.56) ; R256.1 C245.2 v3(103.52,22.7)
  TOP w0.508: v3(37.95,85.57) 39.37,87 49.02,87 49.53,87.51 53.26,87.51 54.38,88.63 v3(54.69,88.63) 55.25,88.63 55.67,88.21 55.67,86.59 56.53,85.72 60.44,85.72 60.92,85.25 60.92,84.51 60.88,84.48 v3(60.88,84.45)
  L3_SIG1 w0.254: v3(110.74,122.56) 111.07,122.56 111.79,123.27 114.98,123.27 115.47,122.78 118.52,122.78 119.2,122.1 119.2,116.46 118.59,115.86 118.59,105.29 120.65,103.23 120.65,102.4 119.57,101.31 119.57,98.65 123.58,94.64 137.72,94.64 139.67,96.58 140.86,96.58 141.58,95.86 141.58,90.9 139.7,89.02 139.7,85.04 138.66,84 138.66,73 151.69,59.97 151.69,42.19 149.66,40.16 149.66,33.26 143.36,26.97 127.35,26.97 123.7,23.32 v4(123.7,20.6)
  L3_SIG1 w0.508: v3(54.69,88.63) 54.69,88.98 57.56,91.85 60.48,91.85 60.89,91.44 70.19,91.44 72.82,88.8 v5(72.82,86.44)
  L8_SIG3 w0.508: v3(37.95,85.57) 32.38,85.57 v5(29.18,82.37)
  BOTTOM w0.381: v5(72.82,86.44) 72.8,86.44 71.81,85.45 C441.1 71.81,83.2 FB22.2
  BOTTOM w0.508: v5(35.48,57.23) 37.11,57.23 37.65,57.77 FB30.2 ; v3(60.88,84.45) 60.91,84.45 61.02,84.35 61.34,84.35 61.79,84.8 FB20.2
  vias: v4(122.3,20.6) v4(122.3,19.2) v4(123.7,19.2) v5(32.72,55.24) v5(32.72,54.28) v5(33.68,55.24) v5(33.68,54.28)
VCC0V85_EN: length 123.2
  TOP w0.254: U33.34 105.12,14.27 v3(105.12,14.27)
  L8_SIG3 w0.107: v1(113.64,122.21) 114.12,122.68 115.32,122.68 115.54,122.46 115.54,118.9 115.72,118.73 115.72,112.58 114.65,111.51 114.65,60.02 117.7,56.97 117.7,20.71 111.27,14.27 v3(105.12,14.27)
  BOTTOM w0.152: v1(113.64,122.21) R337.2
  BOTTOM w0.381: R607.2 v3(105.12,14.27)
VCC0V85_MON: length 3.3
  TOP w0.152: U4.2 113.07,125.02 111.46,123.41 R62.1
VCC1V5: length 185
  TOP w0.254: DIMM1.123 C147.1 94.42,54.37 94.31,54.48 v3(94.31,54.52) ; 141.73,72.03 141.73,73.38 144.27,75.92 148.87,75.92 151.26,78.31 154.41,78.31 154.9,77.82 v5(154.9,76.61) R204.1 ; v3(94.26,56.7) 94.42,56.55 C140.1 94.86,55.97 94.95,55.88 95.79,55.88 95.88,55.97 DIMM1.115 ; DIMM1.93 C125.1 v3(94.42,63.38) ; v3(94.42,60.98) C130.1 DIMM1.101 ; DIMM1.109 95.98,57.77 v1(95.76,57.99) ; v3(108.08,128.78) 108.58,128.78 108.77,128.96 R29.2 ; DIMM1.131 C155.1 v3(94.42,51.98) ; DIMM1.85 C124.1 v3(94.42,65.78)
  TOP w0.305: v3(107.64,57.42) 107.59,57.47 DIMM1.110
  TOP w0.356: DIMM1.94 v3(107.62,62.27) ; DIMM1.86 v3(107.62,64.67) ; DIMM1.132 v3(107.62,50.87) ; DIMM1.124 v3(107.62,53.27) ; DIMM1.116 v3(107.62,55.67) ; DIMM1.102 v3(107.62,59.87)
  TOP w0.381: U23.H13 v6(69.58,64.56) ; U23.D14 v6(72.78,63.76) ; v6(71.18,52.56) U23.F27 v6(70.38,53.36) U23.G26 v6(69.58,54.16) U23.H25 ; U23.C11 v6(73.58,66.16) ; U23.H21 v6(69.58,57.36) ; U23.D5 v6(72.78,70.96) ; U23.A32 v6(75.18,48.56) ; U23.F7 v6(71.18,69.36) ; U23.C17 v6(73.58,61.36) ; U23.C21 v6(73.58,57.36) ; U23.H11 v6(69.58,66.16) U23.G10 v6(70.38,66.96) U23.F9 v6(71.18,67.76) ; v6(71.18,57.36) U23.F21 v6(70.38,58.16) U23.G20 v6(69.58,58.96) U23.H19 ; U23.B33 v6(74.38,47.76) ; v6(71.18,50.96) U23.F29 v6(70.38,51.76) U23.G28 v6(69.58,52.56) U23.H27 ; U23.G30 v6(70.38,50.16) ; v6(71.18,64.56) U23.F13 v6(70.38,63.76) U23.G14 v6(69.58,62.96) U23.H15 ; U23.D27 v6(72.78,52.56) ; U23.D29 v6(72.78,50.96) ; U23.F19 v6(71.18,58.96) ; U23.C3 v6(73.58,72.56) ; U23.F17 v6(71.18,61.36) ; U23.D19 v6(72.78,58.96) ; U23.C31 v6(73.58,49.36) ; U23.D9 v6(72.78,67.76) ; U23.C25 v6(73.58,54.16) ; U23.H23 v6(69.58,55.76) ; U23.H17 v6(69.58,61.36) ; U23.C7 v6(73.58,69.36) ; U23.H7 v6(69.58,69.36) ; U23.H9 v6(69.58,67.76) ; U23.F5 v6(71.18,70.96) ; U23.B1 v6(74.38,74.16) ; U23.F25 v6(71.18,54.16) ; U23.A2 v6(75.18,73.36) ; U23.D23 v6(72.78,55.76) ; U23.F23 v6(71.18,55.76) ; U23.F11 v6(71.18,66.16)
  TOP w0.508: TP44.1 137.03,72.01
  L5_SIG2 w0.254: v3(108.08,128.78) 108.74,128.12 108.74,127.53 109.22,127.05 109.22,123.55 108.47,122.79 108.47,121.91 110.39,119.99 111.43,119.99 112.42,119 112.42,118.5 114.88,116.04 114.88,87.63 110.9,83.64 110.9,67.94 v3(107.62,64.67)
  BOTTOM w0.254: C480.1 v6(73.58,69.36) ; C622.1 v6(70.38,58.16) ; C720.1 v6(71.18,50.96) ; C713.1 v6(70.38,51.76) ; C706.1 v6(69.58,52.56) ; C553.1 v6(69.58,64.56) ; C685.1 v6(69.58,54.16) ; C564.1 v6(72.78,63.76) ; C565.1 v6(70.38,63.76) ; C637.1 v6(71.18,57.36) ; C612.1 v6(71.18,58.96) ; C488.1 v6(69.58,69.36) ; C595.1 v6(71.18,61.36) ; C475.1 v6(72.78,70.96) ; C613.1 v6(69.58,58.96) ; C705.1 v6(71.18,52.56) ; C577.1 v6(69.58,62.96) ; C507.1 v6(72.78,67.76) ; C552.1 v6(71.18,64.56) ; C533.1 v6(73.58,66.16) ; C510.1 v6(71.18,67.76) ; C487.1 v6(71.18,69.36) ; C472.1 v6(73.58,72.56) ; C671.1 v6(72.78,55.76) ; C663.1 v6(71.18,55.76) ; C536.1 v6(71.18,66.16) ; C519.1 v6(70.38,66.96) ; C638.1 v6(69.58,57.36) ; C697.1 v6(70.38,53.36) ; C611.1 v6(72.78,58.96) ; C721.1 v6(72.78,50.96) ; C684.1 v6(71.18,54.16) ; C664.1 v6(69.58,55.76) ; C691.1 v6(73.58,54.16)
  BOTTOM w0.279: U74.2 117.51,34.7 117.04,34.24
  BOTTOM w0.381: C602.1 69.51,61.3 v6(69.58,61.36) ; C601.1 73.63,61.31 v6(73.58,61.36) ; R549.1 v5(121.44,30.75)
  vias: v5(113.49,34.11) v5(113.49,32.97) v5(136.32,69.72) v5(136.32,68.33) v5(137.34,69.72) v5(137.34,68.33)
VCC1V5_EN: length 109.5
  TOP w0.152: R56.2 v1(120.4,121.41)
  TOP w0.254: v5(150.37,71.37) 150.73,71.01 U22.10
  L10_SIG4 w0.107: v5(150.37,71.37) 155.04,76.05 160.88,76.05 169.31,84.47 169.31,88.07 168.58,88.8 168.58,106.95 168.66,107.03 168.66,107.45 168.63,107.47 168.63,108.69 166.55,110.77 159.03,110.77 156.54,113.26 155.65,113.26 154.2,114.71 154.2,117.1 147.19,124.12 126.66,124.12 126.24,123.7 123.16,123.7 121.06,121.6 120.58,121.6 v1(120.4,121.41)
  BOTTOM w0.152: R610.2 v5(150.37,71.37)
VCC1V5_MON: length 2.2
  TOP w0.152: U4.42 110.49,129.54 110.24,129.29 R29.1
VCC1V8: length 280.5
  TOP w0.254: v1(98.81,103.61) 99.35,103.07 R127.2 ; C474.1 136.94,49.35 136.7,49.58 v1(136.42,49.58) ; C474.1 R428.1 ; C474.1 137.19,49.38 NOR1.2 ; v1(85.01,32.99) 84.63,33.38 84.63,34.45 R242.2 ; C25.2 58.12,113.14 57.92,113.33 57.02,113.33 56.94,113.25 U10.20 ; C25.2 v1(59.39,113.14) ; C25.2 C29.1 ; v1(66.27,115.1) 66.4,115.23 C22.2 ; R88.2 60.93,114.02 v3(60.83,113.92) ; v3(104.99,2.29) C292.2 R274.1 ; U11.1 83.47,112.49 83.29,112.67 83.29,113.85 v3(83.34,113.9) ; R626.2 52.15,95.22 v3(52.27,95.1) ; C20.2 58.8,119.48 58.67,119.61 C19.1 ; v1(135.13,46.86) 136.27,46.86 136.65,46.48 R443.1 ; C27.1 C28.2 v5(46.12,114.05) ; CN7.2 v3(36.83,97.99) ; R239.2 v1(87.43,34.82) ; U14.20 47.68,106.93 47.45,107.16 v3(47.27,107.16) ; v3(42.47,94.82) 42.59,94.94 R627.2 ; U16.20 47.68,100.48 v3(48.16,100.97) ; v3(40.67,97.46) 40.8,97.59 CN7.1 ; R244.2 93.93,35.33 v1(94.08,35.18) ; C19.1 58.01,120.07 57.92,120.16 U6.20 ; C19.1 v3(59.42,120.07) ; C215.1 38.08,33.78 38.3,34.01 v3(38.3,34.03) ; R44.2 v3(101.41,125.73) ; C15.1 161.79,130.22 v1(162.56,130.22) ; v3(93.07,105.74) 93.07,105.38 93.35,105.1 R109.2 ; v1(63.87,115.1) 64.25,114.72 C26.1 ; R31.2 v3(102.17,129.61) ; R64.2 v3(104.27,122.56) ; v5(47.05,114.63) C23.2 C24.1 ; R45.1 89.81,125.35 v3(89.61,125.55) ; C21.2 64.8,116.03 v1(64.67,115.9)
  TOP w0.381: v6(59.98,51.76) U23.W28 v6(60.78,52.56) U23.V27 ; U21.1 C97.1 v3(22.54,77.03) ; U23.U28 v6(62.38,51.76) ; v6(56.78,51.76) U23.AC28 v6(57.58,52.56) U23.AB27 ; v6(65.58,51.76) U23.N28 v6(64.78,52.56) U23.P27 ; v6(67.18,51.76) U23.L28 v6(66.38,52.56) U23.M27 ; U23.U31 v6(62.38,49.36) ; U23.Y7 v6(59.18,69.36) ; v3(54.69,87.92) 54.69,87.08 54.43,86.81 R182.2 R183.2 52.05,86.54 51.07,86.54 R184.2 ; v3(22.14,80.06) 22.75,80.06 R200.1 ; v6(68.78,51.76) U23.J28 v6(67.98,52.56) U23.K27 ; U23.AJ30 v6(51.98,50.16) ; v3(86.77,123.95) R53.2 R66.2 ; U23.V7 v6(60.78,69.36) ; U23.AA3 v6(58.38,72.56) ; v3(59.29,109.52) C30.1 58.85,108.64 58.57,108.36 U13.5 ; U23.M2 v6(66.38,73.36) ; FB11.1 35.69,26.26 36.12,25.83 36.12,25.78 v5(36.09,25.78) ; U23.Y27 v6(59.18,52.56) U23.AA28 v6(58.38,51.76) ; U23.AA8 v6(58.38,68.56) U23.AB7 v6(57.58,69.36) ; v6(63.98,51.76) U23.R28 v6(63.18,52.56) U23.T27 ; U23.AM33 v6(49.58,47.76) ; R74.2 v1(69.41,117.16) ; U23.L8 v6(67.18,68.56) ; v6(66.38,69.36) U23.M7 v6(65.58,68.56) U23.N8 ; U23.AG26 v6(53.58,53.36) U23.AH27 v6(52.78,52.56) ; U23.P7 v6(64.78,69.36) ; U23.AC8 v6(56.78,68.56) ; v5(28.59,28.82) 28.6,28.83 28.93,28.83 29.27,29.17 FB9.1 ; v6(55.18,51.76) U23.AE28 v6(55.98,52.56) U23.AD27 ; U23.AE31 v6(55.18,49.36) ; R197.1 v3(23.44,81.85) ; U23.AD4 v6(55.98,71.76) ; U23.T7 v6(63.18,69.36) ; U23.AA31 v6(58.38,49.36) ; U23.AN32 v6(48.78,48.56) ; U23.AE26 v6(55.18,53.36) U23.AF27 v6(54.38,52.56) ; U23.AE8 v6(55.18,68.56) ; U23.N31 v6(65.58,49.36) ; U23.J2 v6(68.78,73.36)
  TOP w0.508: v1(43.37,92.39) 43,92.76 42.32,92.76 41.76,93.32 41.76,94.35 42.23,94.82 v3(42.47,94.82) ; FB7.1 v5(24.13,39.29)
  L5_SIG2 w0.508: v1(94.08,35.18) 92.92,36.34 88.95,36.34 v1(87.43,34.82) 86.41,33.8 85.82,33.8 v1(85.01,32.99)
  L8_SIG3 w0.381: v6(66.38,69.36) 66.44,69.36 66.7,69.62
  L10_SIG4 w0.254: v6(55.98,71.76) 56.24,71.5 ; v6(58.38,72.56) 58.17,72.35
  BOTTOM w0.152: v6(68.78,73.36) 68.37,73.76 66.78,73.76 v6(66.38,73.36) ; v6(60.78,69.36) 60.38,69.75 59.64,69.75 C484.1
  BOTTOM w0.254: R378.2 89.47,107.96 89.46,107.95 v3(89.46,107.85) ; R323.2 108.77,129.75 108.95,129.93 v3(109.18,129.93) ; U44.9 v3(74.76,132.56) ; U48.14 v1(162.56,130.22) ; U70.8 26.26,49.42 26.47,49.2 C730.1 v3(26.47,47.92) ; C719.1 v6(56.78,51.76) ; C703.1 v6(55.18,53.36) ; U40.19 C321.1 v3(55.7,138.42) ; U16.20 47.68,100.48 48.16,100.96 v3(48.16,100.97) ; R491.1 v3(111.18,47.37) ; R536.2 86.95,34.35 v1(87.43,34.82) 87.43,35.56 88.04,36.17 R528.2 ; v3(47.27,107.16) 47.68,106.76 U14.20 ; U46.2 C333.1 v3(66.19,130.44) ; C496.1 v6(67.18,68.56) ; v3(26.47,58.65) C635.1 26.03,57.91 25.98,57.96 U68.1 ; v6(59.18,69.36) C484.1 ; v1(55.45,131.98) C335.1 55.42,131.21 U45.2 ; v3(97.59,114.12) R357.1 ; R475.2 v3(15.68,53.16) ; v3(38.3,34.03) 38.28,34.01 U75.7 ; U53.H8 v1(66.27,115.1) ; R468.1 v3(113.23,60.96) ; R553.2 134.55,30.46 v1(134.04,29.95) ; v1(86.35,113.93) C355.1 86.35,112.55 86.47,112.42 U56.1 ; C714.1 v6(59.98,51.76) ; C357.1 83.75,113.49 v3(83.34,113.9) ; v3(112.72,44.7) C736.1 U71.1 ; C470.1 v6(66.38,73.36) ; U64.1 C516.1 v3(112.72,68.58) ; v3(94.74,107.65) C368.1 U55.8 ; U53.J6 v1(64.67,115.9) ; U53.G4 v1(63.87,115.1) ; U75.52 34.57,39.33 C749.1 ; U40.2 C320.1 v3(66.4,137.68) ; R626.2 52.15,95.22 v3(52.27,95.1) ; R423.1 v3(111.82,76.38) ; v3(112.72,78.11) C468.1 EEPROM1.8 ; C483.1 v6(63.18,69.36) ; R555.2 v3(25.91,27.28) ; C707.1 v6(64.78,52.56) ; U53.D3 v1(62.27,111.9) ; R579.2 v1(132.52,7.76) ; C711.1 v6(54.38,52.56) ; R422.2 v3(123.32,75.95) ; U37.7 58.02,142.86 57.76,142.6 57.76,141.98 58.43,141.31 C316.1 v3(57.66,140.7) ; C725.1 v6(51.98,50.16) ; R435.1 v3(111.82,72.14) ; U51.20 47.61,114.87 47.36,114.62 47.06,114.62 v5(47.05,114.63) ; R329.2 v3(56.2,126.82) ; U58.3 43.77,94.59 C417.1 ; U69.2 114.3,51.69 114.12,51.5 C722.1 v3(114.12,50.04) ; R474.1 v3(113.23,55.12) ; C500.1 v6(58.38,68.56) ; U79.3 139.7,120.16 140.77,119.09 C875.1 ; C712.1 60.91,52.7 v6(60.78,52.56) ; U63.A2 83.97,68.45 84.3,68.12 C518.1 84.3,65.04 v3(84,64.74) 84,63.2 83.67,62.87 v5(82.63,62.87) ; R440.1 v3(111.82,70.28) ; U43.9 v3(86.26,129.61) ; U72.8 26.81,42.84 26.98,42.67 C746.1 v3(26.98,41.55) ; C708.1 v6(63.18,52.56) ; v3(56.28,139.67) C317.1 56.77,140.7 57.15,141.08 57.15,143.09 56.9,143.34 56.88,143.34 56.86,143.36 U37.3 ; C710.1 v6(55.98,52.56) ; v5(46.12,114.05) 46.11,114.04 U54.20 ; C489.1 v6(64.78,69.36) ; C717.1 v6(68.78,51.76) ; v3(56.82,131.83) C334.1 U46.19 ; R470.1 v3(113.23,58.93) ; C485.1 v6(57.58,69.36) ; v3(136.09,131.76) C330.1 137.81,131.76 137.89,131.84 U41.2 ; C716.1 v6(55.18,51.76) ; C704.1 v6(53.58,53.36) ; C709.1 v6(59.18,52.56) ; v3(136.28,142.72) 136.28,142.74 C311.1 U38.16 ; R494.1 v3(111.82,46.41) ; C479.1 v6(66.38,69.36) ; R480.1 v3(113.23,53.09) ; C729.1 v6(58.38,49.36) ; C502.1 v6(55.18,68.56) ; C501.1 v6(56.78,68.56) ; C473.1 v6(55.98,71.76) ; C497.1 v6(65.58,68.56) ; v6(56.26,41.66) 56.26,42.17 R506.1 ; U57.20 C374.1 92.12,105.33 92.53,105.74 v3(93.07,105.74) ; v5(48.61,135.33) 48.61,134.94 U39.9 ; C718.1 v6(65.58,51.76) ; v3(114.12,55.88) C650.1 114.12,57.35 114.3,57.54 U67.2 ; R537.2 85.24,33.22 v1(85.01,32.99) ; C715.1 v6(58.38,51.76) ; R425.2 v3(123.32,74.42) ; v6(68.78,73.36) C471.1 ; R317.2 v3(136.17,135.95)
  BOTTOM w0.305: v3(42.47,94.82) 42.88,94.82 43.33,94.36 C417.1 ; C875.1 140.77,118.68 140.64,118.54 v1(140.64,118.31) ; v1(43.37,92.39) 43.37,92.39 43,92.02 C893.1 43.37,91.69 43.45,91.77 44,91.77 44.26,91.51 U80.23 44.73,91.85 44.86,91.98 U80.24
  BOTTOM w0.381: 29.42,52.39 28.81,52.39 28.09,53.11 15.72,53.11 v3(15.68,53.16) ; 29.42,52.39 28.55,51.53 v3(28.55,51.1) ; 29.42,52.39 C696.1 30.17,52.39 30.89,51.67 v3(30.89,51.1) ; v5(36.46,26.76) 36.45,26.76 36.17,26.47 FB33.1 ; C749.1 v3(36,39.56) ; v4(44.15,27.36) 43.16,28.35 FB10.1
  BOTTOM w0.508: FB24.2 v5(38.76,82)
  vias: v1(147.68,52.4) v1(147.7,51.61) v4(122.3,6.61) v4(122.3,5.21) v4(123.7,6.61) v4(123.7,5.21) v5(30.28,68.99) v5(31.22,68.99) v5(32.64,57.68) v5(32.64,56.72) v5(33.6,57.68) v5(33.6,56.72) v5(48.71,35.12) v5(48.71,34.23) v5(49.4,41.53) v5(50.55,41.53) v5(74.17,82.04) v5(75.77,86.11) v5(76.66,86.11) v5(141.88,49.29) v5(149.99,21.08) v5(149.99,20.19) v5(155.43,34.66) v5(155.46,33.7)
VCC1V8_EN: length 137.7
  TOP w0.152: v1(122.56,129.67) 122.56,129.87 122.25,130.18 R26.2
  TOP w0.254: U33.27 v3(105.12,10.77)
  L8_SIG3 w0.107: v3(105.12,10.77) 112.67,10.77 118.95,17.05 118.95,30.99 118.63,31.31 118.63,36.4 118.92,36.69 118.92,37.12 118.34,37.69 118.26,37.69 117.93,38.02 117.93,57.06 114.88,60.11 114.88,111.09 116.46,112.67 116.46,121.87 122.53,127.94 122.53,128 122.56,128.02 v1(122.56,129.67)
  BOTTOM w0.381: v3(105.12,10.77) 104.38,11.51 R606.2
VCC1V8_MON: length 2.5
  TOP w0.152: U4.41 v3(110.88,130.04)
  BOTTOM w0.152: v3(110.88,130.04) 110.88,130.03 110.13,129.29 R323.1
VCC1V8_TCT: length 12.2
  BOTTOM w0.381: R570.2 148.15,15.55 147.76,15.94 147.76,17.21 148.84,18.29 150.5,18.29 151.83,19.63 FB34.2 C815.1 151.83,22.67 151.07,23.44 151.07,23.87 R556.2
VCC2V5: length 220.5
  TOP w0.381: TP95.1 138.56,23.9 v5(138.61,23.95) ; v3(140.79,28.09) 140.64,27.94 139.7,27.94 138.61,26.85 v5(138.61,24.77) ; v1(47.73,92.72) 47.4,92.4 C894.1
  L3_SIG1 w0.381: 171.94,23.74 J9.13A ; J9.13A 173.43,25.24 ; J9.13A 173.43,23.74 ; J9.13A 171.94,25.24 ; 157.25,12.31 J9.11B ; J9.11B 158.74,13.81 ; J9.11B 158.74,12.31 ; J9.11B 157.25,13.81 ; 161.06,27.78 J9.13B ; J9.13B 162.55,27.78 ; J9.13B 161.06,26.28 ; J9.13B 162.55,26.28 ; 171.94,13.81 J9.11A ; J9.11A 171.94,12.31 ; J9.11A 173.43,13.81
  L8_SIG3 w0.508: v3(75.04,99.28) 70.93,103.39 57.2,103.39 50.9,97.1 v3(50.9,94.48) 49.14,92.72 v1(47.73,92.72) 47.73,95.33 47.04,96.01 43.41,96.01 v1(42.01,97.41)
  L10_SIG4 w0.508: v3(75.04,99.28) 75.15,99.17 75.15,96.65 80.49,91.31 85.55,91.31 86.63,92.39 90.77,92.39 94.7,96.33 109.77,96.33 130.66,75.44 130.66,49.85 129.82,49.01 129.82,45.95 130.19,45.57 v1(130.19,39.93)
  BOTTOM w0.254: v1(134.75,19.86) 134.72,19.83 U77.11 ; U73.49 v1(130.19,38.43) ; U77.49 v1(128.24,14.8) ; U73.52 v1(130.19,39.93) ; U58.7 49.46,94.09 49.85,93.7 C423.1 50.65,94.24 v3(50.9,94.48) ; U73.11 v1(136.75,41.88) ; U77.52 v1(128.24,16.3)
  BOTTOM w0.305: v1(47.73,92.72) 47.32,92.72 47.21,92.61 U80.1
  BOTTOM w0.381: v3(140.79,28.09) 140.94,27.94 R647.1 ; R625.2 42.73,97.05 42.37,97.41 v1(42.01,97.41) 41.58,97.41 41.4,97.23 R624.2
  BOTTOM w0.508: J9.13A 170.53,22.33 C889.1 ; C888.1 C886.1 171.45,11.82 J9.11A ; v3(162.29,10.4) v3(161.28,10.4) C887.1 159.89,10.54 C885.1 J9.11B ; C889.1 170,23.27 169.7,23.57 167.84,23.57 167.08,24.33 167.08,28.5 v1(166.03,29.55) v1(165.03,29.55) C891.1 C892.1 J9.13B ; C889.1 C890.1
VCC2V5_EN: length 4.9
  BOTTOM w0.254: Q15.5 146.66,27.34 R650.2 C895.1 R649.2
VCC3_AUX_MON: length 3.8
  TOP w0.152: U4.39 110.1,131.04 v3(109.67,131.47) R21.1
  BOTTOM w0.152: R21.1 v3(109.67,131.47)
VCC3_LCD: length 12.4
  BOTTOM w0.254: LCD1.12 61.41,144.87 61.15,144.61 C304.1 61.15,142.27 62,141.42 R309.2 63.24,141.42 63.87,142.06 65.78,142.06 65.8,142.04 Q10.2 67.41,142.04 67.82,142.44 R306.2
VCC3V3_AUX: length 241.3
  TOP w0.254: v3(91.74,105.82) 91.77,105.82 91.62,105.97 89.49,105.97 B1.1 ; R73.2 v3(176.97,116.91) ; C290.2 v3(96.06,3.17) ; B2.1 85.75,105.92 v3(85.57,105.75) ; v3(107.95,132.13) 108.03,132.21 R21.2 ; R252.2 R251.2 v3(93.18,31.67) ; v3(81.16,104.34) 81.42,104.08 R113.1 ; v3(12.76,83) R193.2 R198.2 ; R276.2 v1(56.88,4.54) ; R161.1 v3(74.44,96.14) ; v3(15.16,84.65) 15.29,84.78 R188.2 ; R614.1 v3(169.48,141.55) ; CN7.62 v5(33.35,117.99) ; v5(42.16,133.1) 42.16,132.69 41.97,132.49 CN7.119 ; R71.2 v3(177.1,119.28) 177.07,119.25 176.4,119.25 176.21,119.45 R69.2 ; R273.1 v3(96.06,4.57) ; CN7.120 34.04,132.49 33.78,132.75 v5(33.78,133.22) ; R35.2 v5(29.39,129.17) ; U11.14 88.71,112.49 88.62,112.57 88.6,112.57 v3(88.42,112.75) ; U7.16 v3(87.75,120.62) ; R201.2 12.76,79.54 13.21,79.99 v3(13.21,80.01) ; B3.1 v3(71.92,107.07) ; v5(40.8,117.35) CN7.61 ; R136.2 v3(63.5,102.68) ; R89.2 v3(176.97,114.38) ; U35.3 56.01,2.74 C296.1 56.38,2.64 v3(56.82,2.2) ; DIMM1.199 v3(99.11,30.77) ; B4.1 v3(69.09,107.01)
  TOP w0.305: v3(103.7,109.3) 104.85,109.3 105.41,108.74 C31.1 104.7,108.07 104.55,108.22 U12.5
  TOP w0.381: v5(133.2,60.22) 133.7,60.72 R215.2 ; v3(102.51,110.74) 102.81,110.45 R100.2 ; v3(42.6,29.29) 43.3,30 C796.1 ; v5(151.87,66.52) 152,66.66 R213.2 ; U21.8 C98.1 v3(13.66,76.89) ; Y4.1 52.64,103.44 52.96,103.76 55.44,103.76 Y4.4 56.84,104.21 56.35,104.7 C35.1 v3(55.59,105.44)
  L3_SIG1 w0.508: v3(16.95,37.82) 17.61,38.48 31.75,38.48 32.11,38.84 43.56,38.84 v3(44.6,37.8) 44.6,35.53 42.52,33.45 42.52,29.33 42.6,29.25 v3(42.6,29.29)
  L8_SIG3 w0.508: v5(40.87,87.78) 40.34,87.78 39.53,86.97 32.7,86.97 28.1,82.36 28.1,79.79 27,78.69 25.2,78.69 v5(24.26,79.63)
  L8_SIG3 w0.635: v3(169.8,121.15) 169.07,121.15 168.84,121.38 168.84,128.33 168.06,129.11 168.06,132.41 168.21,132.56 168.21,140.29 v3(169.48,141.55) ; v3(159.89,112.92) 157.21,112.92 155.84,114.29 153.23,114.29 152.64,114.88 152.64,115.27 151.38,116.52 151.38,122.15 147.79,125.75 142.05,125.75 v3(141.56,126.23)
  BOTTOM w0.254: R513.1 15.68,39.09 16.95,37.82 v3(16.95,37.82) ; v3(97.94,119.96) 98.02,119.96 98.24,120.19 U49.16 ; C351.1 95.65,115.49 95.52,115.62 v3(95.52,115.57) ; v3(88.42,112.75) 88.57,112.9 C353.1 ; C348.1 87.75,119.72 v3(87.75,120.62) ; R493.2 v3(122.62,47.24) ; R611.2 56.32,3.63 56.88,4.18 v1(56.88,4.54) ; R339.1 v3(169.8,121.15) ; U50.15 C352.1 C356.1 v3(161.44,112.01) ; v3(15.22,1.7) R595.2 ; U52.8 168.67,115.06 168.53,114.92 v3(168.53,114.3) ; v3(44.6,37.8) 44.58,37.77 U76.3 ; v3(15.22,5.97) R581.2 ; v3(85.67,107.77) 85.7,107.75 C361.1 86.35,108.61 86.47,108.74 U56.6 ; U62.A2 25.04,77.83 ; R508.2 v1(143.22,42.52) ; R377.2 v3(178.3,108.15) ; C737.1 v3(121.72,42.29) ; U76.7 43.31,30 v3(42.6,29.29) 42.04,29.85 U76.8 ; v1(137.87,46.33) 137.87,45.85 R496.2 ; U45.19 C332.1 v3(46.12,132) ; R557.2 v1(136.14,22.56) ; U79.7 140.2,125.86 140.4,126.06 C876.1 141.05,126.75 v3(141.56,126.23) ; R497.2 v3(122.62,45.47) ; v3(99.11,30.77) C789.1 C790.2 ; R361.1 v3(159.89,112.92) ; U74.10 122.56,34.2 ; R482.1 v3(14.96,52.07) ; v3(15.22,3.07) R591.2 ; v3(15.22,7.34) R578.2 ; U70.1 16.75,49.42 16.58,49.24 C731.1 16.59,48.63 v3(16.59,47.9) ; R359.1 v3(163.58,112.78)
  BOTTOM w0.381: C737.1 121.72,43.35 121.25,43.81 U71.8 ; U72.1 16.88,42.84 16.58,42.54 C747.1 v3(16.58,40.99) ; R463.2 23.25,60.61 20.59,57.96 U68.14 17.42,57.96 17.34,58.04 C633.1 16.58,58.76 16.03,59.31 14.55,59.31 14.3,59.56 B7.1 ; v1(145.92,15.62) FB35.1 ; C762.1 v1(150.24,39.43)
  BOTTOM w0.508: v3(169.48,141.55) 168.6,140.67 R615.2 ; FB32.1 v1(148.82,39.4)
  BOTTOM w0.889: B7.1 v4(12.73,60.96)
  vias: v1(147.45,13.08) v3(73.58,90.82) v3(82.58,137.39) v3(83.97,137.39) v3(90.65,100.86) v3(90.68,100.15) v5(24.26,80.59) v5(80.39,2.54) v5(80.39,1.52) v5(81.53,2.54) v5(81.53,1.52) v5(124.84,35.61) v5(125.93,35.61) v5(125.96,34.59) v5(148.11,20.62) v5(148.11,19.81)
VCC3V3_AUX_EN: length 210.7
  TOP w0.254: v3(97.54,8) 98.04,8.5 U33.13
  L3_SIG1 w0.381: v3(97.54,8) 97.54,3.51 98.02,3.02 109.35,3.02 121.68,15.35 125.71,15.35 126.03,15.67 126.03,23.06 127.67,24.7 132.97,24.7 134.67,26.4 147.03,26.4 v1(149.73,29.11)
  L8_SIG3 w0.107: v3(97.54,8) 96.8,8.74 96.8,17.94 97.88,19.02 113.08,19.02 117.47,23.42 117.47,47.02 115.77,48.72 115.77,58.58 114.43,59.92 114.43,72.75 114.02,73.15 114.02,118.83 115.16,119.97 v1(115.16,122.3)
  BOTTOM w0.152: R649.1 v1(149.73,29.11) ; R336.2 115.07,122.21 v1(115.16,122.3)
  BOTTOM w0.381: v3(97.54,8) R605.2
VCC3V3_AUX_F1: length 19.1
  TOP w0.127: U17.7 v3(79.7,94.62)
  TOP w0.254: 88.7,95.15 88.7,94.82 88.5,94.62 U17.30 ; 88.7,95.15 v3(88.7,95.17) ; 88.7,95.15 88.67,95.12 U17.31 ; v3(87.81,91.01) 87.17,91.01 87.05,91.13 U17.24 ; U17.18 84.05,90.73 83.8,90.48 v3(83.59,90.48) ; v3(81,90.47) 81.35,90.47 81.55,90.68 U17.13 ; U17.27 v3(88.75,93.12) ; v3(80.83,98.77) 80.99,98.93 81.36,98.93 81.55,98.74 U17.48 ; U17.10 v3(79.7,93.12) ; v3(84.51,92.38) 84.55,92.33 U17.19 ; U17.34 v3(88.75,96.62)
  TOP w0.381: R602.2 v6(78.06,89.6) ; R601.2 81,89.86 v3(81,90.47)
  BOTTOM w0.152: 90.55,98.2 v3(90.58,98.22)
  BOTTOM w0.254: v3(84.51,92.38) 84.51,91.29 84.68,91.12 C426.1
  BOTTOM w0.381: v3(81,90.47) 81.03,90.45 ; v6(78.06,89.6) 78.06,90.33 78.59,90.86 80.21,90.86
  vias: v3(87.93,98.73) v3(90.6,97.46)
VCC3V3_AUX_F2: length 12.4
  TOP w0.254: v3(61.59,94.49) 61.73,94.62 U18.7 ; U18.30 70.56,94.62 v3(70.86,94.92) 70.66,95.12 U18.31 ; U18.10 62.23,93.12 v3(61.59,93.75) ; v3(62.33,98.17) 62.53,98.37 U18.48 ; v3(63.15,90.8) 63.16,90.8 63.17,90.81 63.37,90.81 63.67,91.11 U18.13 ; v3(66.14,90.42) 66.17,90.45 U18.18 ; v3(70.78,92.99) 70.66,93.12 U18.27 ; U18.19 66.67,90.46 v3(66.87,90.26) ; U18.24 v3(69.17,90.35) ; U18.34 v3(70.86,96.62)
  vias: v3(70.23,90.42) v3(70.23,89.53) v3(70.86,98.53)
VCC3V3_EN: length 140.5
  TOP w0.152: v3(23.67,75.39) 23.67,75.39 R665.2 ; R55.2 v1(121.92,121.41)
  L8_SIG3 w0.107: v1(73.81,118.59) 73.81,118.57 73.48,118.24 72.21,118.24 69.27,115.29 69.27,112.67 64.62,108.03 61.17,108.03 61.16,108.03 59.08,105.94 56.85,105.94 52.73,101.83 45.59,101.83 44.89,101.13 41.72,101.13 38.84,98.25 38.51,98.25 37.49,97.23 33.64,97.23 28.85,92.44 28.85,85.65 26.36,83.15 22.57,83.15 21.09,81.66 21.09,76.31 22,75.39 v3(23.67,75.39)
  BOTTOM w0.152: v1(121.92,121.41) 121.39,120.88 120.37,120.88 119.51,120.02 110.49,120.02 110.26,120.25 109.44,120.25 108.52,121.16 106.92,121.16 105.84,122.24 105.84,123.52 104.27,125.09 91.09,125.09 90.7,124.71 79.93,124.71 v1(73.81,118.59) ; U62.B2 25.04,77.11 25.04,75.94 24.49,75.39 v3(23.67,75.39)
VCC3V3_MP: length 383.9
  TOP w0.254: R10.1 v3(151,136.4) ; v3(148.26,142.42) 148.57,142.73 150.08,142.73 150.31,142.5 R5.2 ; v1(96.72,134.62) 96.98,134.36 C899.1 96.87,133.87 U81.5 ; v5(128.72,142.88) 128.72,142.88 D2.1 D1.1 ; U1.8 132.22,139.66 v3(132.56,139.32) ; U1.93 136.69,145.73 136.5,145.93 v3(136.5,146.58) ; C11.1 105.13,133.97 U3.8 ; v1(70.23,112.7) 70.25,112.69 U8.9 ; v3(142.14,146.15) 142.19,146.1 142.34,146.1 142.69,145.75 U1.81 ; v1(148.62,127.64) 149.53,128.55 R28.1 ; v3(148.18,139.65) 147.62,139.65 147.61,139.66 U1.68 ; R205.2 v3(169.72,75.28) ; v3(136.4,128.02) 136.19,128.22 U1.32 ; U1.44 v3(142.19,128.06) ; U1.3 v3(132.56,142.16) ; R47.2 v3(176.66,125.67) ; R38.2 v3(137.38,126.22) ; R13.1 v3(115.8,135.96) R14.1 ; U1.20 132.28,133.66 132.51,133.43 v3(132.77,133.43) ; R32.2 v3(178.18,127.42) ; Q1.4 v3(115.2,141.99) ; U4.33 114.07,133.5 v3(114.38,133.81) ; U1.56 147.8,133.66 147.89,133.58 148.61,133.58 v3(148.89,133.86) ; R656.2 v1(14.53,35.25) ; R8.2 v3(150.96,137.92) ; R179.2 v3(171.69,87.9)
  TOP w0.381: v3(152.43,136.53) 152.45,136.51 R9.2 ; C11.1 v5(105.52,135.31)
  L8_SIG3 w0.254: v1(14.53,35.25) 29.1,20.68 46.18,20.68 54.91,11.94 66.19,11.94 68.91,9.22 77.06,9.22 77.32,9.48 v1(77.32,9.5)
  L8_SIG3 w0.508: v1(156.34,120.4) 154.41,120.4 149.41,125.39 v3(149.41,126.57) 150.22,127.38 157.45,127.38 161.7,123.14 161.7,117.42 166.55,112.57 166.55,107.49 166.54,107.48 166.54,104.78 168.45,102.87 169.7,101.62 169.7,100.89 169.72,100.86 169.72,90.41 171.69,88.44 v3(171.69,87.9) 171.69,83.73 170.59,82.63 170.59,76.15 v3(169.72,75.28)
  L10_SIG4 w0.254: v3(169.72,75.28) 170.43,74.56 170.43,73.3 166.47,69.34 166.47,56.46 162.61,52.6 162.61,42.48 157.89,37.75 157.89,34.98 145.07,22.16 145.07,19.29 142.62,16.84 141.88,16.84 139.62,14.58 139.62,13.28 137.72,11.38 136.27,11.38 135.66,10.77 131.53,10.77 131.1,10.34 127.27,10.34 126.98,10.05 126.52,10.05 126.23,10.34 121.77,10.34 121.11,9.68 116.87,9.68 116.69,9.5 v1(77.32,9.5)
  BOTTOM w0.254: R311.1 v3(100.91,138.75) ; v3(132.56,139.32) 131.95,139.32 131.77,139.13 C319.1 ; 114.41,65.66 C542.1 112.72,65.03 112.73,65.02 v3(112.73,64.85) ; v1(149.94,128.14) 150.31,128.52 C340.1 C336.1 ; R338.1 v3(109.05,122.21) ; R316.1 v3(94.92,138.24) ; R360.2 v1(156.34,120.4) ; R315.1 v3(89.84,138.24) ; v3(136.4,128.02) 136.14,128.27 C339.1 ; U38.1 146.86,142.74 147.07,142.53 C314.1 147.93,142.09 v3(148.26,142.42) ; U42.8 v3(133.22,132.06) ; R335.1 R334.1 v3(117.47,121.41) ; U38.3 146.01,141.44 146.18,141.6 146.18,141.96 146.05,142.09 ; R466.1 v3(122.62,61.21) ; R305.2 v3(100.84,144.43) ; U41.19 146.26,131.84 146.77,131.33 C331.1 147.95,131.33 v3(148.34,130.94) ; R307.1 v3(115.95,142.01) ; v3(132.77,133.43) 132.16,133.43 131.77,133.04 C325.1 ; R322.1 v3(149.41,132.39) ; R314.1 v3(92.38,138.24) ; Q1.4 v3(115.2,141.99) ; R459.1 v3(122.62,63.05) ; R326.1 v3(149.41,126.57) ; C337.1 v3(142.19,128.06) ; v3(121.72,66.8) C515.1 U64.8 ; v3(121.72,64.77) C541.1 120.03,65.66 ; C323.1 148.32,133.28 v3(148.89,133.86) ; U47.15 v1(153.64,128.98) ; R306.1 v5(70.11,141.35) ; C312.1 v3(132.56,142.16) ; R313.1 v3(97.46,138.24) ; R298.2 v3(112.01,145.85)
  BOTTOM w0.305: U38.2 C314.1
  BOTTOM w0.381: v3(118.72,146.25) 118.52,146.06 C297.1 117.92,144.39 117.69,144.17 U36.5 ; R299.2 114.47,145.71 v1(114.1,146.08) ; C303.1 v5(128.72,142.88)
  vias: v3(109.65,142.9) v3(109.65,142.01) v3(110.67,142.9)
VCC3V3_MP_ALT: length 3
  TOP w0.254: TP8.1 123.57,130.81 v3(123.9,131.14)
  TOP w0.381: D1.2 125.6,146.05 v3(126.01,145.64)
  BOTTOM w0.254: R292.1 v3(130.51,144.58)
  vias: v3(120.62,137.88) v3(121.67,137.88)
VCC3V3_MP_ALT_DET: length 4.7
  TOP w0.152: v1(133.69,146.48) U1.99
  BOTTOM w0.152: v1(133.69,146.48) 133.69,145.81 133.37,145.48 R291.2 R292.2
VCC3V3_MP_AMC: length 259.8
  TOP w0.254: R190.2 v3(13.44,83.88)
  TOP w0.381: v3(122.61,146.02) 122.61,144.44 123.29,143.76 D2.2
  TOP w0.483: v5(9.83,7.5) AMC1.4
  L3_SIG1 w0.254: v3(13.44,83.88) 15.95,81.36 15.95,60.66 12.7,57.4 12.7,25.07 14.94,22.83 14.94,14.35 11.38,10.79 11.38,8.43 10.45,7.5 v5(9.83,7.5)
  L8_SIG3 w0.254: v3(122.61,146.02) 122.6,146 121.51,146 120.66,146.85 99.71,146.85 98.53,145.67 89.61,145.67 88.43,146.85 39.69,146.85 35.71,142.88 33.96,142.88 26.41,135.32 26.41,86.07 25.57,85.23 14.79,85.23 v3(13.44,83.88)
VCC3V3_PCIE: length 21.7
  TOP w0.762: v3(13.66,65.61) 13.13,65.07 v4(13.13,62.89) 17.3,62.89 22,67.58 26.42,67.58 v4(26.62,67.39)
  BOTTOM w0.254: R451.1 v3(13.66,65.61)
  BOTTOM w0.305: U65.10 25.25,68.05 ; U65.11 25.26,67.4
VCC5_MON: length 5
  TOP w0.152: U4.38 110.65,131.54 110.36,131.83 v3(110.36,133.76) R18.1
  BOTTOM w0.152: R320.2 v3(110.36,133.76)
VCC5V: length 227.8
  TOP w0.254: v5(42.42,113.28) 42.42,112.72 42.19,112.49 CN7.59 ; v5(33.15,112.51) 33.17,112.49 CN7.60 ; TP50.1 v5(149.02,57.66) ; R18.2 v3(108.08,133.76)
  TOP w0.305: C777.1 154.88,53.87 v1(154.86,53.85)
  TOP w0.381: R219.2 v5(129.37,52.25)
  L5_SIG2 w0.635: v3(108.08,133.76) 108.12,133.79 109.31,133.79 110.09,134.58 115.56,134.58 117.68,136.71 119.54,136.71 120.03,136.22 120.03,132.36 120.7,131.69 121.6,131.69 122.92,130.37 130.06,130.37 132.67,127.76 132.67,127.03 135.74,123.96 135.74,122.85 136.88,121.7 138.76,121.7 139.12,122.06 153.9,122.06 155,120.96 155,120.96 155.56,120.4 155.56,114.79 157.34,113.01 158.71,113.01 162.06,109.66 162.06,101.8 162.86,101.01 163.83,101.01 164.38,100.47 164.38,97.81 165.16,97.02 165.16,93.85 165.32,93.7 165.32,90.94 160.22,85.85 160.22,77.42 158.17,75.37 158.17,66.52 ; v5(33.15,112.51) 33.92,113.28 v5(42.42,113.28)
  L10_SIG4 w0.635: v3(108.08,133.76) 107.37,134.47 103.58,134.47 95.57,126.46 88.27,126.46 87.39,125.58 78.79,125.58 77.95,126.42 70.07,126.42 68,124.35 62.15,124.35 61.65,124.85 45.53,124.85 43.92,123.24 42.68,123.24 41.65,122.22 41.65,114.06 v5(42.42,113.28)
  BOTTOM w0.381: R245.2 154.41,53.39 v1(154.86,53.85) 154.87,53.86 U32.5 ; J8.4 19.71,17.45 ; J8.4 18.3,18.87 ; J8.4 19.71,18.87 ; J8.4 18.3,17.45
  vias: v1(30.48,13.36) v1(30.99,14.27) v1(31.6,13.36) v1(32.13,14.27) v1(32.77,13.36) v1(33.55,14.25) v1(34.21,13.39) v5(131.84,52.58) v5(148.11,58.9) v5(148.11,57.63) v5(149,58.9) v5(160.99,31.39) v5(161.11,33.86) v5(161.11,32.79) v5(161.9,32.11) v5(162.33,33.91)
VCC5V_EN: length 151.8
  TOP w0.152: R60.2 114.4,121.52 114.43,121.49 114.43,121.46 v1(114.39,121.46)
  TOP w0.254: v5(136.32,55.75) 135.96,56.12 U25.10
  L10_SIG4 w0.107: v5(136.32,55.75) 138.18,55.75 139.55,54.38 156.88,54.38 160.91,58.41 160.91,59.28 160.22,59.97 160.22,66.09 165.84,71.7 165.84,80.47 169.53,84.16 169.53,88.22 168.86,88.89 168.86,106.91 168.88,106.93 168.88,107.54 168.86,107.57 168.86,108.79 166.65,111 166.46,111 159.12,111 156.62,113.5 155.74,113.5 154.43,114.8 154.43,119.72 149.8,124.35 136.12,124.35 134.34,126.12 129.67,126.12 129.25,125.7 124.84,125.7 120.96,121.83 117.78,121.83 117.69,121.92 114.91,121.92 114.45,121.46 v1(114.39,121.46)
  BOTTOM w0.381: R609.2 v5(136.32,55.75)
VCC12: length 187.5
  TOP w0.381: v4(41.4,14.73) 41.4,19.06 45.97,23.62 TP61.1 R254.1
  TOP w0.635: 27.2,9.01 F1.2 ; F1.2 28.61,9.01 ; F1.2 28.61,10.42 ; F1.2 27.2,10.42 ; R267.2 v4(50.8,6.48)
  L3_SIG1 w1.016: v4(77.8,17.45) 79.71,19.35 81.28,19.35 85.57,23.65 v5(85.57,26.06)
  L5_SIG2 w0.762: v5(125.17,50.19) 125.02,50.34 125.02,65.02 131.17,71.17 138.11,71.17 139.7,72.77 142.18,75.24 156.69,75.24 159.27,77.82 159.27,89 161.65,91.38 161.65,94.51 159.27,96.88 159.27,108.37 159.11,108.53 159.11,110.49 157.53,112.06 156.95,112.06 154.61,114.4 154.61,120.01 153.51,121.11 139.95,121.11 139.6,120.75 135.2,120.75 131.86,124.09 131.86,126.3 129.92,128.24 v3(129.92,129.16)
  L9_PWR2 w0.381: 18.3,25.07 J8.1 ; J8.1 18.3,26.49 ; J8.1 19.71,26.49 ; J8.1 19.71,25.07 ; 9.45,87.05 J4.A1 8.55,87.05 ; F1.2 28.63,8.99 ; F1.2 27.18,10.44 ; F1.2 28.63,10.44 ; F1.2 27.18,8.99 ; J4.B2 10.65,89.55 ; J4.B2 10.65,88.65 ; J4.B2 9.75,89.55 ; J4.B2 9.75,88.65 ; 8.55,88.65 J4.A2 ; J4.A2 8.55,89.55 ; J4.A2 9.45,88.65 ; J4.A2 9.45,89.55 ; 10.65,87.05 J4.B1 9.75,87.05
  BOTTOM w0.381: 18.08,26.71 J8.1 ; J8.1 19.93,24.85 ; J8.1 18.08,24.85 ; J8.1 19.93,26.71
  BOTTOM w0.889: FAN1.2 85.28,29.19 C797.1
  BOTTOM w1.016: C797.1 85.57,26.76 v5(85.57,26.06)
  vias: v3(129.03,129.16) v4(40.01,14.73) v4(40.01,13.34) v4(40.01,11.94) v4(41.4,13.34) v4(41.4,11.94) v4(77.8,16.28) v4(77.8,14.96) v4(77.77,13.74) v5(125.15,49.02) v5(126.59,50.22) v5(126.64,48.97) v5(127.69,50.19) v5(127.69,48.97) v5(160.07,74.3) v5(160.12,73.28) v5(161.49,74.3) v5(161.49,73.25) v5(164.11,74.27) v5(164.11,73.25)
VCC12_AMC: length 140.6
  TOP w0.381: v5(8.26,66.98) 7.73,67.5 AMC1.84 ; AMC1.2 8.41,6 v5(8.41,6) ; v5(9.63,59.08) 9.05,58.5 AMC1.72 ; v5(9.88,18.21) 9.66,17.99 2.93,17.99 2.92,18 AMC1.18 ; AMC1.27 8.9,24.75 v5(9.63,25.48) ; v5(9.65,36) AMC1.42
  TOP w0.483: v5(9.83,11.25) AMC1.9 ; v5(9.63,48.01) 8.87,47.25 AMC1.57
  TOP w0.635: J11.1 20.61,3.13 ; J11.1 16.15,5.09 ; J11.1 20.61,5.09 ; J11.1 16.15,3.13 ; F1.1 26.63,4.55 ; F1.1 24.78,4.55 ; F1.1 26.63,6.4 ; F1.1 24.78,6.4
  L4_PWR1 w0.381: 16.15,3.13 J11.1 ; J11.1 20.61,5.09 ; J11.1 16.15,5.09 ; J11.1 20.61,3.13 ; 24.98,6.2 F1.1 ; F1.1 24.98,4.75 ; F1.1 26.43,4.75 ; F1.1 26.43,6.2
  L5_SIG2 w0.381: J11.1 20.61,3.13 ; J11.1 20.61,5.09 ; J11.1 16.15,3.13 ; J11.1 16.15,5.09 ; 24.98,4.75 F1.1 ; F1.1 26.43,6.2 ; F1.1 26.43,4.75 ; F1.1 24.98,6.2
  L8_SIG3 w0.381: F1.1 26.43,4.75 ; F1.1 24.98,4.75 ; F1.1 26.43,6.2 ; F1.1 24.98,6.2 ; 16.15,3.13 J11.1 ; J11.1 20.61,5.09 ; J11.1 20.61,3.13 ; J11.1 16.15,5.09
  L10_SIG4 w0.381: 16.15,5.09 J11.1 ; J11.1 20.61,3.13 ; J11.1 16.15,3.13 ; J11.1 20.61,5.09 ; F1.1 26.43,4.75 ; F1.1 26.43,6.2 ; F1.1 24.98,4.75 ; F1.1 24.98,6.2
  BOTTOM w0.381: J11.1 20.61,3.13 ; J11.1 16.15,5.09 ; J11.1 16.15,3.13 ; J11.1 20.61,5.09 ; 24.78,4.55 F1.1 ; F1.1 26.63,4.55 ; F1.1 24.78,6.4 ; F1.1 26.63,6.4
VCCPLLA1A: length 8
  TOP w0.254: U18.37 69.17,98.79 69.7,99.31 71.27,99.31 72.11,100.16 C49.1
  TOP w0.381: C49.1 C41.1 72.11,103.05 71.92,103.25 B3.3
VCCPLLA2A: length 8.2
  TOP w0.254: C48.1 90.04,100.45 89.69,100.1 88.09,100.1 87.05,99.06 U17.37
  TOP w0.381: B1.3 89.53,103.28 90.04,102.78 C39.1 90.04,102.11 90.06,102.09 90.06,101.38 90.04,101.37 C48.1
VDD33: length 21.5
  TOP w0.254: v1(43.69,91.19) 43.75,91.13 R172.1 ; U23.Y11 v6(59.18,66.16) ; U23.P11 v6(64.78,66.16) ; TP39.1 27.69,80.06 v5(28.73,79.02)
  L5_SIG2 w0.152: v6(59.18,66.16) 59.57,65.76 60.14,65.76 60.38,65.99 60.38,66.33 60.61,66.56 60.94,66.56 61.17,66.79 61.17,67.12 62.21,68.16 64.94,68.16 65.17,67.93 65.17,66.57 64.78,66.17
  L5_SIG2 w0.188: v6(64.78,66.16) 64.78,66.17
  BOTTOM w0.127: U62.A1 25.86,77.93
  BOTTOM w0.152: C539.1 C557.1
  BOTTOM w0.254: C545.1 v6(64.78,66.16) C537.1 ; v6(59.18,66.16) C539.1
  BOTTOM w0.508: v5(32.74,67.11) 32.74,67.09 32.7,67.06 32.65,67.11 C517.1 FB27.2
  vias: v3(46,83.9) v5(28.73,78.05) v5(30.76,77.93) v5(31.57,77.9) v5(50.14,80.62) v5(50.98,80.62)
VDD_USB_0: length 2.8
  TOP w0.254: U23.U10 v6(62.38,66.96) ; U23.V11 v6(60.78,66.16)
  BOTTOM w0.254: C529.1 60.86,66.24 v6(60.78,66.16) ; v6(62.38,66.96) 62.35,66.93 C528.1
  BOTTOM w0.508: FB20.1 60.33,85.19 v3(60.15,85.01)
VDD_USB_1: length 4.1
  TOP w0.254: U23.T11 v6(63.18,66.16) ; U23.R12 v6(63.98,65.36)
  BOTTOM w0.254: C538.1 v6(63.18,66.16) ; C546.1 v6(63.98,65.36)
  BOTTOM w0.508: FB30.1 38.91,58.6 39.65,58.6 40.13,59.08 v5(40.13,59.13)
VDDA: length 2.7
  TOP w0.254: U33.19 v3(101.04,7.37)
  BOTTOM w0.254: v3(101.04,7.37) 100.84,7.17 C853.2
VDDAHV: length 12.8
  TOP w0.254: U23.AH19 v6(52.78,58.96) ; v6(53.58,54.16) U23.AH25 ; U23.AH13 v6(52.78,64.56) ; U23.AH17 v6(52.78,61.36) ; U23.AH23 v6(52.78,55.76) ; U23.AH11 v6(52.78,66.16) ; U23.AH21 v6(52.78,57.36) ; U23.AH15 v6(52.78,62.96)
  BOTTOM w0.152: C695.1 53.98,55.1 53.97,55.11 53.97,55.12 53.74,55.35 53.72,55.35 53.72,55.36 53.25,55.36 C670.1 53.18,54.47 53.49,54.16 v6(53.58,54.16)
  BOTTOM w0.254: C583.1 v6(52.78,62.96) ; C621.1 v6(52.78,58.96) C620.1 ; C561.1 v6(52.78,64.56) ; C695.1 v6(53.58,54.16) ; C598.1 v6(52.78,61.36) ; C648.1 v6(52.78,57.36) C647.1 ; C540.1 v6(52.78,66.16) ; C670.1 v6(52.78,55.76)
  vias: v5(32.41,62.31) v5(32.41,61.09) v5(33.63,62.31) v5(33.63,61.09)
VDDALV: length 27.6
  TOP w0.381: v6(53.58,54.96) U23.AG24 v6(54.38,55.76) U23.AF23 v6(55.18,56.56) U23.AE22 ; v6(54.38,64.56) U23.AF13 v6(55.18,63.76) U23.AE14 ; v6(54.38,54.16) U23.AF25 v6(55.18,54.96) U23.AE24 ; v6(54.38,62.96) U23.AF15 v6(55.18,62.16) U23.AE16 ; v6(54.38,67.76) U23.AF9 v6(55.18,66.96) U23.AE10 ; v6(53.58,56.56) U23.AG22 v6(54.38,57.36) U23.AF21 v6(55.18,58.16) U23.AE20 ; U23.AE12 v6(55.18,65.36) U23.AF11 v6(54.38,66.16) ; v6(53.58,58.16) U23.AG20 v6(54.38,58.96) U23.AF19 v6(55.18,59.76) U23.AE18 U23.AF17 v6(54.38,61.36) U23.AG16 v6(53.58,62.16) ; U23.AG18 v6(53.58,59.76)
  BOTTOM w0.254: C680.1 v6(55.18,54.96) ; C631.1 v6(53.58,58.16) ; C609.1 v6(53.58,59.76) ; C593.1 v6(53.58,62.16) ; C630.1 v6(55.18,58.16) ; C550.1 v6(55.18,65.36) ; C592.1 v6(55.18,62.16) ; C659.1 v6(53.58,56.56) ; C527.1 v6(55.18,66.96) ; C646.1 v6(54.38,57.36) ; C560.1 v6(54.38,64.56) ; C572.1 v6(55.18,63.76) ; C514.1 v6(54.38,67.76) ; C669.1 v6(54.38,55.76)
  vias: v5(32.61,50.77) v5(32.61,49.81) v5(33.58,50.77) v5(33.58,49.81)
VDDCMON: length 30.7
  TOP w0.152: U23.J10 v6(68.78,66.96)
  TOP w0.254: R545.1 73.96,86.72 v1(73.96,86.64) 74.53,86.08 TP86.1
  L5_SIG2 w0.107: v1(73.96,86.64) 73.46,87.15 72.56,87.15 71.88,86.47 71.88,81.61 72.67,80.82 72.67,75.7 73.94,74.43 73.94,73.27 74.22,72.99 74.46,72.99 74.8,72.65 74.8,70.88 74.74,70.83 74.74,70.81 74.53,70.59 74.29,70.59 73.94,70.25 73.94,70.01 73.73,69.79 73.49,69.79 73.21,69.51 73.21,69.25 72.89,68.93 72.62,68.93 72.41,68.71 72.41,68.45 72.16,68.2 72.14,68.2 72.13,68.19 70.29,68.19 69.94,67.84 69.94,67.57 69.7,67.33 69.14,67.33 v6(68.78,66.96)
  BOTTOM w0.254: C520.1 v6(68.78,66.96)
VDDCMON_R: length 157.8
  TOP w0.254: v1(75.48,87.1) 74.89,87.68 74.27,87.68 R545.2 R544.1
  TOP w0.305: U34.31 v3(61.34,6.51)
  L3_SIG1 w0.152: v1(75.48,87.1) 77.21,87.1 77.5,86.8 95.22,86.8 97.32,84.7 99.32,84.7 99.54,84.93 105.99,84.93 106.79,84.12 107.52,84.12 113.31,78.34 113.31,64.44 112.17,63.3 112.17,49.85 109.75,47.44 109.75,46.16 109.39,45.8 106.65,45.8 106.07,45.21 102.9,45.21 101.96,44.27 97.99,44.27 96.72,43 91.21,43 86.94,38.73 79.39,38.73 76.61,35.95 76.61,30.21 79.48,27.34 79.48,22.82 76.72,20.07 71.76,20.07 62.66,10.97 62.66,7.83 v3(61.34,6.51)
VDDD: length 73.6
  TOP w0.254: R272.1 100.33,4.01 v1(100.2,3.88) ; U33.20 101.54,7.45 v3(101.75,7.24)
  L3_SIG1 w0.254: v1(102.54,20.78) 111.99,20.78 113.94,18.82 113.94,10.03 112.52,8.61 105.74,8.61 103.96,6.83 102.69,6.83 102.29,7.24 v3(101.75,7.24)
  BOTTOM w0.254: R282.1 102.01,20.53 102.25,20.78 v1(102.54,20.78) ; C852.2 101.97,6.41 101.75,6.63 v3(101.75,7.24)
  BOTTOM w0.508: R567.1 98.04,17.6 97.89,17.45 96.32,17.45 94.89,16.03 94.89,8.26 94.91,8.24 94.91,6.74 94.89,6.73 94.89,3.01 95.81,2.09 98.5,2.09 99.01,2.6 99.01,3.11 99.78,3.88 v1(100.2,3.88) 101.06,3.02 102.26,3.02 103.5,4.26 103.5,5.87 102.96,6.41 C852.2
VDDG: length 3.7
  TOP w0.254: U33.18 v3(100.54,8.13)
  BOTTOM w0.254: v3(100.54,8.13) 100.08,7.67 100.08,6.6 99.89,6.41 C854.2
VDDPLL0: length 6.3
  TOP w0.254: U23.E14 v6(71.98,63.76) ; U23.G16 v6(70.38,62.16) ; U23.G24 v6(70.38,54.96) ; U23.G22 v6(70.38,56.56) ; U23.G8 v6(70.38,68.56)
  BOTTOM w0.152: 72.37,64.9 72.37,64.22
  BOTTOM w0.178: C551.1 72.37,64.9 ; 72.37,64.22 C562.1
  BOTTOM w0.254: C651.1 v6(70.38,56.56) ; v6(71.98,63.76) C562.1 ; C674.1 v6(70.38,54.96) ; C586.1 v6(70.38,62.16) ; C495.1 v6(70.38,68.56)
  vias: v5(79.17,62.87)
VSS_RTC: length 8.9
  TOP w0.152: C32.1 v1(154.81,106.75) ; C37.1 v1(154.57,103.69)
  TOP w0.254: U15.H18 v1(152.22,104.88)
  L3_SIG1 w0.254: v1(154.81,106.75) 154.57,106.51 v1(154.57,103.69) 154.18,103.3 153.39,103.3 152.87,103.82 152.87,104.23 v1(152.22,104.88)
VSSCMON: length 30.4
  TOP w0.152: U23.J9 v6(68.78,67.76)
  TOP w0.254: TP93.1 74.26,89.57 v1(73.84,89.15) 74.48,88.52 R547.1
  L5_SIG2 w0.107: v6(68.78,67.76) 69.18,68.16 69.7,68.16 69.7,68.16 69.94,68.41 69.94,68.64 70.29,68.99 72.13,68.99 72.41,69.27 72.41,69.51 72.69,69.79 72.93,69.79 73.21,70.07 73.21,70.31 73.42,70.53 73.8,70.53 73.99,70.71 73.99,72.67 73.73,72.93 73.43,72.93 73.14,73.21 73.14,74.49 72.34,75.29 72.34,80.82 71.65,81.51 71.65,86.56 73.84,88.75 v1(73.84,89.15)
  BOTTOM w0.254: C503.1 v6(68.78,67.76)
VSSCMON_R: length 161
  TOP w0.254: R546.2 R547.2 74.27,88.09 75.39,88.09 75.64,88.34 v1(75.64,89.2)
  TOP w0.305: U34.32 61.52,6.01 61.21,5.71 v3(61.21,5.7)
  L3_SIG1 w0.152: v1(75.64,89.2) 77.76,87.08 95.34,87.08 97.44,84.98 99.2,84.98 99.42,85.2 106.11,85.2 106.91,84.4 107.64,84.4 112.44,79.6 113.59,78.46 113.59,64.32 112.45,63.18 112.45,49.74 110.03,47.32 110.03,46.05 109.5,45.52 106.77,45.52 106.18,44.93 103.1,44.93 102.17,44 98.13,44 96.85,42.72 91.32,42.72 87.05,38.46 79.51,38.46 76.89,35.83 76.89,30.33 79.76,27.46 79.76,22.71 76.84,19.79 71.88,19.79 65.34,13.25 65.3,13.25 62.94,10.89 62.94,7.43 v3(61.21,5.7)
25M_CLK_REFN: length 3.6
  TOP w0.102: R167.2 59.94,92.18 60,92.24 62.14,92.24 62.26,92.12 U18.12
25M_CLK_REFP: length 5.2
  TOP w0.102: U18.11 62.26,92.62 62.14,92.5 60.05,92.5 59.94,92.6 R164.2 R163.2
25M_SEC_REFN: length 15.5
  TOP w0.102: R177.1 79.55,87.8 79.33,87.59 79.33,86.74 79.03,86.44 77.14,86.44 76.28,87.3 76.28,89.96 75.59,90.65 74.78,90.65 74.4,91.04 74.4,91.72 74.04,92.08 71.13,92.08 70.97,92.24 70.7,92.24 70.58,92.12 U18.25
25M_SEC_REFP: length 15.4
  TOP w0.102: R178.1 78.95,87.8 79.08,87.67 79.08,86.84 78.93,86.69 78.57,86.69 78.46,86.79 78.24,86.79 78.13,86.69 77.91,86.69 77.8,86.79 77.58,86.79 77.47,86.69 77.25,86.69 76.53,87.41 76.53,90.07 76.22,90.38 75.69,90.91 74.89,90.91 74.65,91.14 74.65,91.82 74.14,92.33 73.83,92.33 73.72,92.43 73.5,92.43 73.39,92.33 73.17,92.33 73.06,92.43 72.84,92.43 72.73,92.33 71.24,92.33 71.07,92.5 70.7,92.5 70.58,92.62 U18.26
9090FPWM4: length 14.8
  TOP w0.152: v1(119.13,125.86) 118.82,126.17 U4.13
  BOTTOM w0.152: v1(119.13,125.86) 119.13,125.17 122.34,121.96 122.34,117.94 CN5.1
9090FPWM6: length 13.6
  TOP w0.152: U4.15 119.38,127.54 120.05,126.86 v1(120.05,126.75)
  BOTTOM w0.152: CN5.2 123.76,119.06 123.76,122.59 120.05,126.3 v1(120.05,126.75)
9090FPWM7: length 11.7
  TOP w0.152: v1(120.07,127.55) 119.76,127.87 119.76,127.87 119.59,128.04 U4.16
  BOTTOM w0.152: v1(120.07,127.55) 120.08,127.55 124.51,123.12 124.51,120.85 125.73,119.63 CN5.3
9090FPWM8: length 10.2
  TOP w0.152: U4.17 v1(119.76,128.54)
  BOTTOM w0.152: v1(119.76,128.54) 121.93,126.36 122.65,126.36 124.72,124.29 125.73,123.28 CN5.4
AMC0_SGMII2_RX_DN: length 59.2
  TOP w0.102: AMC1.15 4.84,15.75 5.09,15.5 10.5,15.5 12.14,17.14 12.14,21.45 17.81,27.12 17.81,35.8 26.89,44.87 32.97,44.87 38.07,49.97 40.16,49.97 40.32,50.13 C157.2
AMC0_SGMII2_RX_DN_R: length 10.1
  TOP w0.102: C157.1 41.22,50.06 41.3,49.97 42.79,49.97 46.3,53.49 48.9,53.49 U23.AN26
AMC0_SGMII2_RX_DP: length 59.3
  TOP w0.102: AMC1.14 4.84,15 5.09,15.25 10.6,15.25 12.4,17.04 12.4,21.35 18.07,27.02 18.07,35.69 26.99,44.62 33.08,44.62 38.18,49.72 40.21,49.72 40.32,49.61 C158.2
AMC0_SGMII2_RX_DP_R: length 10
  TOP w0.102: C158.1 41.22,49.6 41.33,49.72 42.89,49.72 46.41,53.23 48.9,53.23 U23.AN27
AMC0_SGMII2_TX_DN: length 80.5
  TOP w0.102: AMC1.12 4.84,13.5 5.09,13.25 11.29,13.25 v1(11.5,13.46) ; U23.AL27 v6(50.38,52.56)
  BOTTOM w0.102: v1(11.5,13.46) 11.28,13.24 10.71,13.24 10.62,13.34 10.62,16.48 13.56,19.43 13.56,30.91 22.56,39.9 28.39,39.9 29.34,40.85 29.34,43.85 30.1,44.62 33.54,44.62 33.87,44.28 37.11,44.28 38.3,45.48 38.3,50.85 39.07,51.61 44.23,51.61 45.36,52.74 45.81,52.74 46.02,52.53 46.25,52.53 46.46,52.74 46.69,52.74 46.9,52.53 47.13,52.53 47.34,52.74 47.57,52.74 47.77,52.53 48,52.53 48.21,52.74 48.44,52.74 48.65,52.53 48.88,52.53 49.09,52.74 49.32,52.74 49.53,52.53 49.75,52.53 49.96,52.74 50.22,52.74 50.38,52.59 v6(50.38,52.56)
AMC0_SGMII2_TX_DP: length 80.5
  TOP w0.102: U23.AL26 v6(50.38,53.36) ; AMC1.11 4.84,12.75 5.09,13 11.27,13 v1(11.5,12.77)
  BOTTOM w0.102: v6(50.38,53.36) 50.01,52.99 45.25,52.99 44.13,51.86 38.96,51.86 38.05,50.95 38.05,45.58 37,44.54 33.98,44.54 33.65,44.87 29.99,44.87 29.08,43.96 29.08,40.96 28.28,40.16 22.45,40.16 13.31,31.01 13.31,19.53 10.36,16.59 10.36,13.23 10.61,12.99 11.28,12.99 v1(11.5,12.77)
AMC1_SGMII3_RX_DN: length 55.1
  TOP w0.102: C146.2 40.32,53.16 40.18,53.02 38.93,53.02 32.9,46.99 27.68,46.99 16.21,35.52 16.21,26.95 11.52,22.25 5.09,22.25 4.84,22.5 AMC1.24
AMC1_SGMII3_RX_DN_R: length 10.2
  TOP w0.102: U23.AM25 49.59,54.95 48.43,54.95 48.21,54.72 45.9,54.72 44.2,53.02 41.3,53.02 41.22,53.11 C146.1
AMC1_SGMII3_RX_DP: length 55.2
  TOP w0.102: AMC1.23 4.84,21.75 5.09,22 11.62,22 16.46,26.84 16.46,35.41 27.79,46.74 33.01,46.74 39.04,52.77 40.23,52.77 40.32,52.69 C153.2
AMC1_SGMII3_RX_DP_R: length 10.2
  TOP w0.102: U23.AM26 49.56,54.17 48.48,54.17 48.22,54.43 45.96,54.43 44.3,52.77 41.33,52.77 41.22,52.65 C153.1
AMC1_SGMII3_TX_DN: length 73.7
  TOP w0.102: v1(10.69,20.2) 10.49,20 5.09,20 4.84,20.25 AMC1.21 ; U23.AK26 v6(51.18,53.36)
  BOTTOM w0.102: v6(51.18,53.36) 51.18,53.5 50.88,53.79 50.22,53.79 50.08,53.94 49.63,53.94 49.47,53.78 49.24,53.78 49.09,53.94 48.86,53.94 48.7,53.78 48.47,53.78 48.31,53.94 48.08,53.94 47.93,53.78 47.7,53.78 47.54,53.94 47.31,53.94 47.15,53.78 46.92,53.78 46.77,53.94 46.54,53.94 46.38,53.78 46.15,53.78 45.99,53.94 45.76,53.94 45.61,53.78 45.38,53.78 45.22,53.94 44.98,53.94 43.53,52.49 39.11,52.49 37.45,50.84 37.45,49.17 33.76,45.48 29.63,45.48 28.74,44.59 28.74,41.24 28.03,40.54 21.29,40.54 11.87,31.12 11.87,23.75 9.73,21.6 9.73,20.09 9.83,19.99 10.48,19.99 v1(10.69,20.2)
AMC1_SGMII3_TX_DP: length 73.7
  TOP w0.102: AMC1.20 4.84,19.5 5.09,19.75 10.46,19.75 v1(10.69,19.52) ; U23.AK25 v6(51.18,54.16)
  BOTTOM w0.102: v1(10.69,19.52) 10.48,19.73 9.72,19.73 9.47,19.98 9.47,21.71 11.62,23.85 11.62,31.23 21.18,40.79 27.93,40.79 28.48,41.35 28.48,44.69 29.52,45.73 33.66,45.73 37.2,49.28 37.2,50.94 39,52.74 43.43,52.74 44.88,54.19 49.89,54.19 50.22,54.53 50.53,54.53 50.9,54.16 v6(51.18,54.16)
AMC2_SATA0_RX_DN: length 27.5
  TOP w0.102: v1(14.12,29.74) 13.91,29.54 13.24,29.54 13.15,29.62 C226.2
  L10_SIG4 w0.102: v1(33.21,29.02) 33.42,29.23 33.42,29.7 33.2,29.92 23.13,29.92 22.97,29.77 22.74,29.77 22.59,29.92 22.36,29.92 22.21,29.77 21.98,29.77 21.83,29.92 21.6,29.92 21.45,29.77 21.22,29.77 21.07,29.92 20.84,29.92 20.69,29.77 20.46,29.77 20.31,29.92 20.08,29.92 19.93,29.77 19.7,29.77 19.54,29.92 19.32,29.92 19.16,29.77 18.93,29.77 18.78,29.92 18.55,29.92 18.4,29.77 18.17,29.77 18.02,29.92 17.79,29.92 17.64,29.77 17.41,29.77 17.26,29.92 17.03,29.92 16.88,29.77 16.65,29.77 16.5,29.92 16.27,29.92 15.79,30.4 15.13,30.4 14.93,30.2 14.7,30.2 14.5,30.4 14.27,30.4 14.07,30.2 13.84,30.2 13.64,30.4 13.42,30.4 13.14,30.12 13.14,29.78 13.36,29.56 13.93,29.56 v1(14.12,29.74)
  BOTTOM w0.102: U75.22 33.37,29.74 33.45,29.66 33.45,29.26 v1(33.21,29.02)
